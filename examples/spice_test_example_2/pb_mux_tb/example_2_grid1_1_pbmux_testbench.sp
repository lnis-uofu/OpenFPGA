*****************************
*     FPGA SPICE Netlist    *
* Description: FPGA SPICE Routing MUX Test Bench for Design: example_2 *
*    Author: Xifan TANG     *
* Organization: EPFL/IC/LSI *
* Date: Thu Nov 15 14:26:08 2018
 *
*****************************
****** Include Header file: circuit design parameters *****
.include './spice_test_example_2/include/design_params.sp'
****** Include Header file: measurement parameters *****
.include './spice_test_example_2/include/meas_params.sp'
****** Include Header file: stimulation parameters *****
.include './spice_test_example_2/include/stimulate_params.sp'
****** Include subckt netlists: NMOS and PMOS *****
.include './spice_test_example_2/subckt/nmos_pmos.sp'
****** Include subckt netlists: Inverters, Buffers *****
.include './spice_test_example_2/subckt/inv_buf_trans_gate.sp'
****** Include subckt netlists: Multiplexers *****
.include './spice_test_example_2/subckt/muxes.sp'
****** Include subckt netlists: Wires *****
.include './spice_test_example_2/subckt/wires.sp'
.include '/research/ece/lnis/USERS/tang/tangxifan-eda-tools/branches/vpr7_rram/vpr/SpiceNetlists/ff.sp'
.include '/research/ece/lnis/USERS/tang/tangxifan-eda-tools/branches/vpr7_rram/vpr/SpiceNetlists/sram.sp'
.include '/research/ece/lnis/USERS/tang/tangxifan-eda-tools/branches/vpr7_rram/vpr/SpiceNetlists/io.sp'
.temp 25
.option fast
***** Generic global ports *****
***** VDD, GND  *****
.global gvdd
.global ggnd
***** Global set ports *****
.global gset gset_inv
***** Global reset ports *****
.global greset greset_inv
***** Configuration done ports *****
.global gconfig_done gconfig_done_inv
***** Global SRAM input *****
.global sram->in
***** Global Clock Signals *****
.global gclock
.global gclock_inv
***** User-defined global ports ******
.global

***** BEGIN Global ports *****
+  zin[0]  clk[0]  Reset[0]  Set[0]
***** END Global ports *****
Xmux_2level_size50[0] mux_2level_size50[0]->in[0] mux_2level_size50[0]->in[1] mux_2level_size50[0]->in[2] mux_2level_size50[0]->in[3] mux_2level_size50[0]->in[4] mux_2level_size50[0]->in[5] mux_2level_size50[0]->in[6] mux_2level_size50[0]->in[7] mux_2level_size50[0]->in[8] mux_2level_size50[0]->in[9] mux_2level_size50[0]->in[10] mux_2level_size50[0]->in[11] mux_2level_size50[0]->in[12] mux_2level_size50[0]->in[13] mux_2level_size50[0]->in[14] mux_2level_size50[0]->in[15] mux_2level_size50[0]->in[16] mux_2level_size50[0]->in[17] mux_2level_size50[0]->in[18] mux_2level_size50[0]->in[19] mux_2level_size50[0]->in[20] mux_2level_size50[0]->in[21] mux_2level_size50[0]->in[22] mux_2level_size50[0]->in[23] mux_2level_size50[0]->in[24] mux_2level_size50[0]->in[25] mux_2level_size50[0]->in[26] mux_2level_size50[0]->in[27] mux_2level_size50[0]->in[28] mux_2level_size50[0]->in[29] mux_2level_size50[0]->in[30] mux_2level_size50[0]->in[31] mux_2level_size50[0]->in[32] mux_2level_size50[0]->in[33] mux_2level_size50[0]->in[34] mux_2level_size50[0]->in[35] mux_2level_size50[0]->in[36] mux_2level_size50[0]->in[37] mux_2level_size50[0]->in[38] mux_2level_size50[0]->in[39] mux_2level_size50[0]->in[40] mux_2level_size50[0]->in[41] mux_2level_size50[0]->in[42] mux_2level_size50[0]->in[43] mux_2level_size50[0]->in[44] mux_2level_size50[0]->in[45] mux_2level_size50[0]->in[46] mux_2level_size50[0]->in[47] mux_2level_size50[0]->in[48] mux_2level_size50[0]->in[49] mux_2level_size50[0]->out sram[0]->outb sram[0]->out sram[1]->out sram[1]->outb sram[2]->out sram[2]->outb sram[3]->out sram[3]->outb sram[4]->out sram[4]->outb sram[5]->out sram[5]->outb sram[6]->out sram[6]->outb sram[7]->out sram[7]->outb sram[8]->outb sram[8]->out sram[9]->out sram[9]->outb sram[10]->out sram[10]->outb sram[11]->out sram[11]->outb sram[12]->out sram[12]->outb sram[13]->out sram[13]->outb sram[14]->out sram[14]->outb sram[15]->out sram[15]->outb gvdd_mux_2level_size50[0] 0 mux_2level_size50
***** SRAM bits for MUX[0], level=2, select_path_id=0. *****
*****1000000010000000*****
Xsram[0] sram->in sram[0]->out sram[0]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[0]->out) 0
.nodeset V(sram[0]->outb) vsp
Xsram[1] sram->in sram[1]->out sram[1]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[1]->out) 0
.nodeset V(sram[1]->outb) vsp
Xsram[2] sram->in sram[2]->out sram[2]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[2]->out) 0
.nodeset V(sram[2]->outb) vsp
Xsram[3] sram->in sram[3]->out sram[3]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[3]->out) 0
.nodeset V(sram[3]->outb) vsp
Xsram[4] sram->in sram[4]->out sram[4]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[4]->out) 0
.nodeset V(sram[4]->outb) vsp
Xsram[5] sram->in sram[5]->out sram[5]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[5]->out) 0
.nodeset V(sram[5]->outb) vsp
Xsram[6] sram->in sram[6]->out sram[6]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[6]->out) 0
.nodeset V(sram[6]->outb) vsp
Xsram[7] sram->in sram[7]->out sram[7]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[7]->out) 0
.nodeset V(sram[7]->outb) vsp
Xsram[8] sram->in sram[8]->out sram[8]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[8]->out) 0
.nodeset V(sram[8]->outb) vsp
Xsram[9] sram->in sram[9]->out sram[9]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[9]->out) 0
.nodeset V(sram[9]->outb) vsp
Xsram[10] sram->in sram[10]->out sram[10]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[10]->out) 0
.nodeset V(sram[10]->outb) vsp
Xsram[11] sram->in sram[11]->out sram[11]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[11]->out) 0
.nodeset V(sram[11]->outb) vsp
Xsram[12] sram->in sram[12]->out sram[12]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[12]->out) 0
.nodeset V(sram[12]->outb) vsp
Xsram[13] sram->in sram[13]->out sram[13]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[13]->out) 0
.nodeset V(sram[13]->outb) vsp
Xsram[14] sram->in sram[14]->out sram[14]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[14]->out) 0
.nodeset V(sram[14]->outb) vsp
Xsram[15] sram->in sram[15]->out sram[15]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[15]->out) 0
.nodeset V(sram[15]->outb) vsp
***** Signal mux_2level_size50[0]->in[0] density = 0, probability=0.*****
Vmux_2level_size50[0]->in[0] mux_2level_size50[0]->in[0] 0
+  0
***** Signal mux_2level_size50[0]->in[1] density = 0, probability=0.*****
Vmux_2level_size50[0]->in[1] mux_2level_size50[0]->in[1] 0
+  0
***** Signal mux_2level_size50[0]->in[2] density = 0, probability=0.*****
Vmux_2level_size50[0]->in[2] mux_2level_size50[0]->in[2] 0
+  0
***** Signal mux_2level_size50[0]->in[3] density = 0, probability=0.*****
Vmux_2level_size50[0]->in[3] mux_2level_size50[0]->in[3] 0
+  0
***** Signal mux_2level_size50[0]->in[4] density = 0, probability=0.*****
Vmux_2level_size50[0]->in[4] mux_2level_size50[0]->in[4] 0
+  0
***** Signal mux_2level_size50[0]->in[5] density = 0, probability=0.*****
Vmux_2level_size50[0]->in[5] mux_2level_size50[0]->in[5] 0
+  0
***** Signal mux_2level_size50[0]->in[6] density = 0, probability=0.*****
Vmux_2level_size50[0]->in[6] mux_2level_size50[0]->in[6] 0
+  0
***** Signal mux_2level_size50[0]->in[7] density = 0, probability=0.*****
Vmux_2level_size50[0]->in[7] mux_2level_size50[0]->in[7] 0
+  0
***** Signal mux_2level_size50[0]->in[8] density = 0, probability=0.*****
Vmux_2level_size50[0]->in[8] mux_2level_size50[0]->in[8] 0
+  0
***** Signal mux_2level_size50[0]->in[9] density = 0, probability=0.*****
Vmux_2level_size50[0]->in[9] mux_2level_size50[0]->in[9] 0
+  0
***** Signal mux_2level_size50[0]->in[10] density = 0, probability=0.*****
Vmux_2level_size50[0]->in[10] mux_2level_size50[0]->in[10] 0
+  0
***** Signal mux_2level_size50[0]->in[11] density = 0, probability=0.*****
Vmux_2level_size50[0]->in[11] mux_2level_size50[0]->in[11] 0
+  0
***** Signal mux_2level_size50[0]->in[12] density = 0, probability=0.*****
Vmux_2level_size50[0]->in[12] mux_2level_size50[0]->in[12] 0
+  0
***** Signal mux_2level_size50[0]->in[13] density = 0, probability=0.*****
Vmux_2level_size50[0]->in[13] mux_2level_size50[0]->in[13] 0
+  0
***** Signal mux_2level_size50[0]->in[14] density = 0, probability=0.*****
Vmux_2level_size50[0]->in[14] mux_2level_size50[0]->in[14] 0
+  0
***** Signal mux_2level_size50[0]->in[15] density = 0, probability=0.*****
Vmux_2level_size50[0]->in[15] mux_2level_size50[0]->in[15] 0
+  0
***** Signal mux_2level_size50[0]->in[16] density = 0, probability=0.*****
Vmux_2level_size50[0]->in[16] mux_2level_size50[0]->in[16] 0
+  0
***** Signal mux_2level_size50[0]->in[17] density = 0, probability=0.*****
Vmux_2level_size50[0]->in[17] mux_2level_size50[0]->in[17] 0
+  0
***** Signal mux_2level_size50[0]->in[18] density = 0, probability=0.*****
Vmux_2level_size50[0]->in[18] mux_2level_size50[0]->in[18] 0
+  0
***** Signal mux_2level_size50[0]->in[19] density = 0, probability=0.*****
Vmux_2level_size50[0]->in[19] mux_2level_size50[0]->in[19] 0
+  0
***** Signal mux_2level_size50[0]->in[20] density = 0, probability=0.*****
Vmux_2level_size50[0]->in[20] mux_2level_size50[0]->in[20] 0
+  0
***** Signal mux_2level_size50[0]->in[21] density = 0, probability=0.*****
Vmux_2level_size50[0]->in[21] mux_2level_size50[0]->in[21] 0
+  0
***** Signal mux_2level_size50[0]->in[22] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[0]->in[22] mux_2level_size50[0]->in[22] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[0]->in[23] density = 0, probability=0.*****
Vmux_2level_size50[0]->in[23] mux_2level_size50[0]->in[23] 0
+  0
***** Signal mux_2level_size50[0]->in[24] density = 0, probability=0.*****
Vmux_2level_size50[0]->in[24] mux_2level_size50[0]->in[24] 0
+  0
***** Signal mux_2level_size50[0]->in[25] density = 0, probability=0.*****
Vmux_2level_size50[0]->in[25] mux_2level_size50[0]->in[25] 0
+  0
***** Signal mux_2level_size50[0]->in[26] density = 0, probability=0.*****
Vmux_2level_size50[0]->in[26] mux_2level_size50[0]->in[26] 0
+  0
***** Signal mux_2level_size50[0]->in[27] density = 0, probability=0.*****
Vmux_2level_size50[0]->in[27] mux_2level_size50[0]->in[27] 0
+  0
***** Signal mux_2level_size50[0]->in[28] density = 0, probability=0.*****
Vmux_2level_size50[0]->in[28] mux_2level_size50[0]->in[28] 0
+  0
***** Signal mux_2level_size50[0]->in[29] density = 0, probability=0.*****
Vmux_2level_size50[0]->in[29] mux_2level_size50[0]->in[29] 0
+  0
***** Signal mux_2level_size50[0]->in[30] density = 0, probability=0.*****
Vmux_2level_size50[0]->in[30] mux_2level_size50[0]->in[30] 0
+  0
***** Signal mux_2level_size50[0]->in[31] density = 0, probability=0.*****
Vmux_2level_size50[0]->in[31] mux_2level_size50[0]->in[31] 0
+  0
***** Signal mux_2level_size50[0]->in[32] density = 0, probability=0.*****
Vmux_2level_size50[0]->in[32] mux_2level_size50[0]->in[32] 0
+  0
***** Signal mux_2level_size50[0]->in[33] density = 0, probability=0.*****
Vmux_2level_size50[0]->in[33] mux_2level_size50[0]->in[33] 0
+  0
***** Signal mux_2level_size50[0]->in[34] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[0]->in[34] mux_2level_size50[0]->in[34] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[0]->in[35] density = 0, probability=0.*****
Vmux_2level_size50[0]->in[35] mux_2level_size50[0]->in[35] 0
+  0
***** Signal mux_2level_size50[0]->in[36] density = 0, probability=0.*****
Vmux_2level_size50[0]->in[36] mux_2level_size50[0]->in[36] 0
+  0
***** Signal mux_2level_size50[0]->in[37] density = 0, probability=0.*****
Vmux_2level_size50[0]->in[37] mux_2level_size50[0]->in[37] 0
+  0
***** Signal mux_2level_size50[0]->in[38] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[0]->in[38] mux_2level_size50[0]->in[38] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[0]->in[39] density = 0, probability=0.*****
Vmux_2level_size50[0]->in[39] mux_2level_size50[0]->in[39] 0
+  0
***** Signal mux_2level_size50[0]->in[40] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[0]->in[40] mux_2level_size50[0]->in[40] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[0]->in[41] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[0]->in[41] mux_2level_size50[0]->in[41] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[0]->in[42] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[0]->in[42] mux_2level_size50[0]->in[42] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[0]->in[43] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[0]->in[43] mux_2level_size50[0]->in[43] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[0]->in[44] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[0]->in[44] mux_2level_size50[0]->in[44] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[0]->in[45] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[0]->in[45] mux_2level_size50[0]->in[45] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[0]->in[46] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[0]->in[46] mux_2level_size50[0]->in[46] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[0]->in[47] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[0]->in[47] mux_2level_size50[0]->in[47] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[0]->in[48] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[0]->in[48] mux_2level_size50[0]->in[48] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[0]->in[49] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[0]->in[49] mux_2level_size50[0]->in[49] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
Vgvdd_mux_2level_size50[0] gvdd_mux_2level_size50[0] 0 vsp
***** Measurements *****
***** Rise delay *****
.meas tran delay_rise_idle_mux50[0]_in[0]_crossbar trig v(mux_2level_size50[0]->in[0]) val='input_thres_pct_rise*vsp' rise=1 td='clock_period'
+          targ v(mux_2level_size50[0]->out) val='output_thres_pct_rise*vsp' rise=1 td='clock_period'
***** Fall delay *****
.meas tran delay_fall_idle_mux50[0]_in[0]_crossbar trig v(mux_2level_size50[0]->in[0]) val='input_thres_pct_fall*vsp' fall=1 td='clock_period'
+          targ v(mux_2level_size50[0]->out) val='output_thres_pct_fall*vsp' fall=1 td='clock_period'
***** Rise timing period *****
.meas start_rise_idle_mux50[0]_in[0]_crossbar when v(mux_2level_size50[0]->in[0])='slew_lower_thres_pct_rise*vsp' rise=1 td='clock_period'
.meas tran switch_rise_idle_mux50[0]_in[0]_crossbar trig v(mux_2level_size50[0]->in[0]) val='slew_lower_thres_pct_rise*vsp' rise=1 td='clock_period'
+          targ v(mux_2level_size50[0]->out) val='slew_upper_thres_pct_rise*vsp' rise=1 td='clock_period'
***** Fall timing period *****
.meas start_fall_idle_mux50[0]_in[0]_crossbar when v(mux_2level_size50[0]->in[0])='slew_lower_thres_pct_fall*vsp' fall=1 td='clock_period'
.meas tran switch_fall_idle_mux50[0]_in[0]_crossbar trig v(mux_2level_size50[0]->in[0]) val='slew_lower_thres_pct_fall*vsp' fall=1 td='clock_period'
+          targ v(mux_2level_size50[0]->out) val='slew_upper_thres_pct_fall*vsp' fall=1 td='clock_period'
***** Leakage Power Measurement *****
.meas tran mux_2level_size50[0]_leakage_power avg p(Vgvdd_mux_2level_size50[0]) from=0 to='clock_period'
.meas tran leakage_idle_mux50[0]_in[0]_crossbar param='mux_2level_size50[0]_leakage_power'
***** Dynamic Power Measurement *****
.meas tran mux_2level_size50[0]_dynamic_power avg p(Vgvdd_mux_2level_size50[0]) from='clock_period' to='6*clock_period'
.meas tran mux_2level_size50[0]_energy_per_cycle param='mux_2level_size50[0]_dynamic_power*clock_period'
.meas tran dynamic_power_idle_mux50[0]_in[0]_crossbar  param='mux_2level_size50[0]_dynamic_power'
.meas tran energy_per_cycle_idle_mux50[0]_in[0]_crossbar  param='dynamic_power_idle_mux50[0]_in[0]_crossbar*clock_period'
.meas tran dynamic_rise_idle_mux50[0]_in[0]_crossbar avg p(Vgvdd_mux_2level_size50[0]) from='start_rise_idle_mux50[0]_in[0]_crossbar' to='start_rise_idle_mux50[0]_in[0]_crossbar+switch_rise_idle_mux50[0]_in[0]_crossbar'
.meas tran dynamic_fall_idle_mux50[0]_in[0]_crossbar avg p(Vgvdd_mux_2level_size50[0]) from='start_fall_idle_mux50[0]_in[0]_crossbar' to='start_fall_idle_mux50[0]_in[0]_crossbar+switch_fall_idle_mux50[0]_in[0]_crossbar'
.meas tran sum_leakage_power_mux[0to0]
+          param='leakage_idle_mux50[0]_in[0]_crossbar'
.meas tran sum_energy_per_cycle_mux[0to0]
+          param='energy_per_cycle_idle_mux50[0]_in[0]_crossbar'
Xload_inv[0]_no0 mux_2level_size50[0]->out mux_2level_size50[0]->out_out[0] gvdd_load 0 inv size=5
.meas tran sum_leakage_power_pb_mux[0to0]
+          param='leakage_idle_mux50[0]_in[0]_crossbar'
.meas tran sum_energy_per_cycle_pb_mux[0to0]
+          param='energy_per_cycle_idle_mux50[0]_in[0]_crossbar'
Xmux_2level_size50[1] mux_2level_size50[1]->in[0] mux_2level_size50[1]->in[1] mux_2level_size50[1]->in[2] mux_2level_size50[1]->in[3] mux_2level_size50[1]->in[4] mux_2level_size50[1]->in[5] mux_2level_size50[1]->in[6] mux_2level_size50[1]->in[7] mux_2level_size50[1]->in[8] mux_2level_size50[1]->in[9] mux_2level_size50[1]->in[10] mux_2level_size50[1]->in[11] mux_2level_size50[1]->in[12] mux_2level_size50[1]->in[13] mux_2level_size50[1]->in[14] mux_2level_size50[1]->in[15] mux_2level_size50[1]->in[16] mux_2level_size50[1]->in[17] mux_2level_size50[1]->in[18] mux_2level_size50[1]->in[19] mux_2level_size50[1]->in[20] mux_2level_size50[1]->in[21] mux_2level_size50[1]->in[22] mux_2level_size50[1]->in[23] mux_2level_size50[1]->in[24] mux_2level_size50[1]->in[25] mux_2level_size50[1]->in[26] mux_2level_size50[1]->in[27] mux_2level_size50[1]->in[28] mux_2level_size50[1]->in[29] mux_2level_size50[1]->in[30] mux_2level_size50[1]->in[31] mux_2level_size50[1]->in[32] mux_2level_size50[1]->in[33] mux_2level_size50[1]->in[34] mux_2level_size50[1]->in[35] mux_2level_size50[1]->in[36] mux_2level_size50[1]->in[37] mux_2level_size50[1]->in[38] mux_2level_size50[1]->in[39] mux_2level_size50[1]->in[40] mux_2level_size50[1]->in[41] mux_2level_size50[1]->in[42] mux_2level_size50[1]->in[43] mux_2level_size50[1]->in[44] mux_2level_size50[1]->in[45] mux_2level_size50[1]->in[46] mux_2level_size50[1]->in[47] mux_2level_size50[1]->in[48] mux_2level_size50[1]->in[49] mux_2level_size50[1]->out sram[16]->outb sram[16]->out sram[17]->out sram[17]->outb sram[18]->out sram[18]->outb sram[19]->out sram[19]->outb sram[20]->out sram[20]->outb sram[21]->out sram[21]->outb sram[22]->out sram[22]->outb sram[23]->out sram[23]->outb sram[24]->outb sram[24]->out sram[25]->out sram[25]->outb sram[26]->out sram[26]->outb sram[27]->out sram[27]->outb sram[28]->out sram[28]->outb sram[29]->out sram[29]->outb sram[30]->out sram[30]->outb sram[31]->out sram[31]->outb gvdd_mux_2level_size50[1] 0 mux_2level_size50
***** SRAM bits for MUX[1], level=2, select_path_id=0. *****
*****1000000010000000*****
Xsram[16] sram->in sram[16]->out sram[16]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[16]->out) 0
.nodeset V(sram[16]->outb) vsp
Xsram[17] sram->in sram[17]->out sram[17]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[17]->out) 0
.nodeset V(sram[17]->outb) vsp
Xsram[18] sram->in sram[18]->out sram[18]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[18]->out) 0
.nodeset V(sram[18]->outb) vsp
Xsram[19] sram->in sram[19]->out sram[19]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[19]->out) 0
.nodeset V(sram[19]->outb) vsp
Xsram[20] sram->in sram[20]->out sram[20]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[20]->out) 0
.nodeset V(sram[20]->outb) vsp
Xsram[21] sram->in sram[21]->out sram[21]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[21]->out) 0
.nodeset V(sram[21]->outb) vsp
Xsram[22] sram->in sram[22]->out sram[22]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[22]->out) 0
.nodeset V(sram[22]->outb) vsp
Xsram[23] sram->in sram[23]->out sram[23]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[23]->out) 0
.nodeset V(sram[23]->outb) vsp
Xsram[24] sram->in sram[24]->out sram[24]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[24]->out) 0
.nodeset V(sram[24]->outb) vsp
Xsram[25] sram->in sram[25]->out sram[25]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[25]->out) 0
.nodeset V(sram[25]->outb) vsp
Xsram[26] sram->in sram[26]->out sram[26]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[26]->out) 0
.nodeset V(sram[26]->outb) vsp
Xsram[27] sram->in sram[27]->out sram[27]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[27]->out) 0
.nodeset V(sram[27]->outb) vsp
Xsram[28] sram->in sram[28]->out sram[28]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[28]->out) 0
.nodeset V(sram[28]->outb) vsp
Xsram[29] sram->in sram[29]->out sram[29]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[29]->out) 0
.nodeset V(sram[29]->outb) vsp
Xsram[30] sram->in sram[30]->out sram[30]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[30]->out) 0
.nodeset V(sram[30]->outb) vsp
Xsram[31] sram->in sram[31]->out sram[31]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[31]->out) 0
.nodeset V(sram[31]->outb) vsp
***** Signal mux_2level_size50[1]->in[0] density = 0, probability=0.*****
Vmux_2level_size50[1]->in[0] mux_2level_size50[1]->in[0] 0
+  0
***** Signal mux_2level_size50[1]->in[1] density = 0, probability=0.*****
Vmux_2level_size50[1]->in[1] mux_2level_size50[1]->in[1] 0
+  0
***** Signal mux_2level_size50[1]->in[2] density = 0, probability=0.*****
Vmux_2level_size50[1]->in[2] mux_2level_size50[1]->in[2] 0
+  0
***** Signal mux_2level_size50[1]->in[3] density = 0, probability=0.*****
Vmux_2level_size50[1]->in[3] mux_2level_size50[1]->in[3] 0
+  0
***** Signal mux_2level_size50[1]->in[4] density = 0, probability=0.*****
Vmux_2level_size50[1]->in[4] mux_2level_size50[1]->in[4] 0
+  0
***** Signal mux_2level_size50[1]->in[5] density = 0, probability=0.*****
Vmux_2level_size50[1]->in[5] mux_2level_size50[1]->in[5] 0
+  0
***** Signal mux_2level_size50[1]->in[6] density = 0, probability=0.*****
Vmux_2level_size50[1]->in[6] mux_2level_size50[1]->in[6] 0
+  0
***** Signal mux_2level_size50[1]->in[7] density = 0, probability=0.*****
Vmux_2level_size50[1]->in[7] mux_2level_size50[1]->in[7] 0
+  0
***** Signal mux_2level_size50[1]->in[8] density = 0, probability=0.*****
Vmux_2level_size50[1]->in[8] mux_2level_size50[1]->in[8] 0
+  0
***** Signal mux_2level_size50[1]->in[9] density = 0, probability=0.*****
Vmux_2level_size50[1]->in[9] mux_2level_size50[1]->in[9] 0
+  0
***** Signal mux_2level_size50[1]->in[10] density = 0, probability=0.*****
Vmux_2level_size50[1]->in[10] mux_2level_size50[1]->in[10] 0
+  0
***** Signal mux_2level_size50[1]->in[11] density = 0, probability=0.*****
Vmux_2level_size50[1]->in[11] mux_2level_size50[1]->in[11] 0
+  0
***** Signal mux_2level_size50[1]->in[12] density = 0, probability=0.*****
Vmux_2level_size50[1]->in[12] mux_2level_size50[1]->in[12] 0
+  0
***** Signal mux_2level_size50[1]->in[13] density = 0, probability=0.*****
Vmux_2level_size50[1]->in[13] mux_2level_size50[1]->in[13] 0
+  0
***** Signal mux_2level_size50[1]->in[14] density = 0, probability=0.*****
Vmux_2level_size50[1]->in[14] mux_2level_size50[1]->in[14] 0
+  0
***** Signal mux_2level_size50[1]->in[15] density = 0, probability=0.*****
Vmux_2level_size50[1]->in[15] mux_2level_size50[1]->in[15] 0
+  0
***** Signal mux_2level_size50[1]->in[16] density = 0, probability=0.*****
Vmux_2level_size50[1]->in[16] mux_2level_size50[1]->in[16] 0
+  0
***** Signal mux_2level_size50[1]->in[17] density = 0, probability=0.*****
Vmux_2level_size50[1]->in[17] mux_2level_size50[1]->in[17] 0
+  0
***** Signal mux_2level_size50[1]->in[18] density = 0, probability=0.*****
Vmux_2level_size50[1]->in[18] mux_2level_size50[1]->in[18] 0
+  0
***** Signal mux_2level_size50[1]->in[19] density = 0, probability=0.*****
Vmux_2level_size50[1]->in[19] mux_2level_size50[1]->in[19] 0
+  0
***** Signal mux_2level_size50[1]->in[20] density = 0, probability=0.*****
Vmux_2level_size50[1]->in[20] mux_2level_size50[1]->in[20] 0
+  0
***** Signal mux_2level_size50[1]->in[21] density = 0, probability=0.*****
Vmux_2level_size50[1]->in[21] mux_2level_size50[1]->in[21] 0
+  0
***** Signal mux_2level_size50[1]->in[22] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[1]->in[22] mux_2level_size50[1]->in[22] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[1]->in[23] density = 0, probability=0.*****
Vmux_2level_size50[1]->in[23] mux_2level_size50[1]->in[23] 0
+  0
***** Signal mux_2level_size50[1]->in[24] density = 0, probability=0.*****
Vmux_2level_size50[1]->in[24] mux_2level_size50[1]->in[24] 0
+  0
***** Signal mux_2level_size50[1]->in[25] density = 0, probability=0.*****
Vmux_2level_size50[1]->in[25] mux_2level_size50[1]->in[25] 0
+  0
***** Signal mux_2level_size50[1]->in[26] density = 0, probability=0.*****
Vmux_2level_size50[1]->in[26] mux_2level_size50[1]->in[26] 0
+  0
***** Signal mux_2level_size50[1]->in[27] density = 0, probability=0.*****
Vmux_2level_size50[1]->in[27] mux_2level_size50[1]->in[27] 0
+  0
***** Signal mux_2level_size50[1]->in[28] density = 0, probability=0.*****
Vmux_2level_size50[1]->in[28] mux_2level_size50[1]->in[28] 0
+  0
***** Signal mux_2level_size50[1]->in[29] density = 0, probability=0.*****
Vmux_2level_size50[1]->in[29] mux_2level_size50[1]->in[29] 0
+  0
***** Signal mux_2level_size50[1]->in[30] density = 0, probability=0.*****
Vmux_2level_size50[1]->in[30] mux_2level_size50[1]->in[30] 0
+  0
***** Signal mux_2level_size50[1]->in[31] density = 0, probability=0.*****
Vmux_2level_size50[1]->in[31] mux_2level_size50[1]->in[31] 0
+  0
***** Signal mux_2level_size50[1]->in[32] density = 0, probability=0.*****
Vmux_2level_size50[1]->in[32] mux_2level_size50[1]->in[32] 0
+  0
***** Signal mux_2level_size50[1]->in[33] density = 0, probability=0.*****
Vmux_2level_size50[1]->in[33] mux_2level_size50[1]->in[33] 0
+  0
***** Signal mux_2level_size50[1]->in[34] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[1]->in[34] mux_2level_size50[1]->in[34] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[1]->in[35] density = 0, probability=0.*****
Vmux_2level_size50[1]->in[35] mux_2level_size50[1]->in[35] 0
+  0
***** Signal mux_2level_size50[1]->in[36] density = 0, probability=0.*****
Vmux_2level_size50[1]->in[36] mux_2level_size50[1]->in[36] 0
+  0
***** Signal mux_2level_size50[1]->in[37] density = 0, probability=0.*****
Vmux_2level_size50[1]->in[37] mux_2level_size50[1]->in[37] 0
+  0
***** Signal mux_2level_size50[1]->in[38] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[1]->in[38] mux_2level_size50[1]->in[38] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[1]->in[39] density = 0, probability=0.*****
Vmux_2level_size50[1]->in[39] mux_2level_size50[1]->in[39] 0
+  0
***** Signal mux_2level_size50[1]->in[40] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[1]->in[40] mux_2level_size50[1]->in[40] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[1]->in[41] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[1]->in[41] mux_2level_size50[1]->in[41] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[1]->in[42] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[1]->in[42] mux_2level_size50[1]->in[42] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[1]->in[43] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[1]->in[43] mux_2level_size50[1]->in[43] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[1]->in[44] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[1]->in[44] mux_2level_size50[1]->in[44] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[1]->in[45] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[1]->in[45] mux_2level_size50[1]->in[45] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[1]->in[46] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[1]->in[46] mux_2level_size50[1]->in[46] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[1]->in[47] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[1]->in[47] mux_2level_size50[1]->in[47] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[1]->in[48] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[1]->in[48] mux_2level_size50[1]->in[48] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[1]->in[49] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[1]->in[49] mux_2level_size50[1]->in[49] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
Vgvdd_mux_2level_size50[1] gvdd_mux_2level_size50[1] 0 vsp
***** Measurements *****
***** Rise delay *****
.meas tran delay_rise_idle_mux50[1]_in[1]_crossbar trig v(mux_2level_size50[1]->in[0]) val='input_thres_pct_rise*vsp' rise=1 td='clock_period'
+          targ v(mux_2level_size50[1]->out) val='output_thres_pct_rise*vsp' rise=1 td='clock_period'
***** Fall delay *****
.meas tran delay_fall_idle_mux50[1]_in[1]_crossbar trig v(mux_2level_size50[1]->in[0]) val='input_thres_pct_fall*vsp' fall=1 td='clock_period'
+          targ v(mux_2level_size50[1]->out) val='output_thres_pct_fall*vsp' fall=1 td='clock_period'
***** Rise timing period *****
.meas start_rise_idle_mux50[1]_in[1]_crossbar when v(mux_2level_size50[1]->in[0])='slew_lower_thres_pct_rise*vsp' rise=1 td='clock_period'
.meas tran switch_rise_idle_mux50[1]_in[1]_crossbar trig v(mux_2level_size50[1]->in[0]) val='slew_lower_thres_pct_rise*vsp' rise=1 td='clock_period'
+          targ v(mux_2level_size50[1]->out) val='slew_upper_thres_pct_rise*vsp' rise=1 td='clock_period'
***** Fall timing period *****
.meas start_fall_idle_mux50[1]_in[1]_crossbar when v(mux_2level_size50[1]->in[0])='slew_lower_thres_pct_fall*vsp' fall=1 td='clock_period'
.meas tran switch_fall_idle_mux50[1]_in[1]_crossbar trig v(mux_2level_size50[1]->in[0]) val='slew_lower_thres_pct_fall*vsp' fall=1 td='clock_period'
+          targ v(mux_2level_size50[1]->out) val='slew_upper_thres_pct_fall*vsp' fall=1 td='clock_period'
***** Leakage Power Measurement *****
.meas tran mux_2level_size50[1]_leakage_power avg p(Vgvdd_mux_2level_size50[1]) from=0 to='clock_period'
.meas tran leakage_idle_mux50[1]_in[1]_crossbar param='mux_2level_size50[1]_leakage_power'
***** Dynamic Power Measurement *****
.meas tran mux_2level_size50[1]_dynamic_power avg p(Vgvdd_mux_2level_size50[1]) from='clock_period' to='6*clock_period'
.meas tran mux_2level_size50[1]_energy_per_cycle param='mux_2level_size50[1]_dynamic_power*clock_period'
.meas tran dynamic_power_idle_mux50[1]_in[1]_crossbar  param='mux_2level_size50[1]_dynamic_power'
.meas tran energy_per_cycle_idle_mux50[1]_in[1]_crossbar  param='dynamic_power_idle_mux50[1]_in[1]_crossbar*clock_period'
.meas tran dynamic_rise_idle_mux50[1]_in[1]_crossbar avg p(Vgvdd_mux_2level_size50[1]) from='start_rise_idle_mux50[1]_in[1]_crossbar' to='start_rise_idle_mux50[1]_in[1]_crossbar+switch_rise_idle_mux50[1]_in[1]_crossbar'
.meas tran dynamic_fall_idle_mux50[1]_in[1]_crossbar avg p(Vgvdd_mux_2level_size50[1]) from='start_fall_idle_mux50[1]_in[1]_crossbar' to='start_fall_idle_mux50[1]_in[1]_crossbar+switch_fall_idle_mux50[1]_in[1]_crossbar'
.meas tran sum_leakage_power_mux[0to1]
+          param='sum_leakage_power_mux[0to0]+leakage_idle_mux50[1]_in[1]_crossbar'
.meas tran sum_energy_per_cycle_mux[0to1]
+          param='sum_energy_per_cycle_mux[0to0]+energy_per_cycle_idle_mux50[1]_in[1]_crossbar'
Xload_inv[1]_no0 mux_2level_size50[1]->out mux_2level_size50[1]->out_out[0] gvdd_load 0 inv size=5
.meas tran sum_leakage_power_pb_mux[0to1]
+          param='sum_leakage_power_pb_mux[0to0]+leakage_idle_mux50[1]_in[1]_crossbar'
.meas tran sum_energy_per_cycle_pb_mux[0to1]
+          param='sum_energy_per_cycle_pb_mux[0to0]+energy_per_cycle_idle_mux50[1]_in[1]_crossbar'
Xmux_2level_size50[2] mux_2level_size50[2]->in[0] mux_2level_size50[2]->in[1] mux_2level_size50[2]->in[2] mux_2level_size50[2]->in[3] mux_2level_size50[2]->in[4] mux_2level_size50[2]->in[5] mux_2level_size50[2]->in[6] mux_2level_size50[2]->in[7] mux_2level_size50[2]->in[8] mux_2level_size50[2]->in[9] mux_2level_size50[2]->in[10] mux_2level_size50[2]->in[11] mux_2level_size50[2]->in[12] mux_2level_size50[2]->in[13] mux_2level_size50[2]->in[14] mux_2level_size50[2]->in[15] mux_2level_size50[2]->in[16] mux_2level_size50[2]->in[17] mux_2level_size50[2]->in[18] mux_2level_size50[2]->in[19] mux_2level_size50[2]->in[20] mux_2level_size50[2]->in[21] mux_2level_size50[2]->in[22] mux_2level_size50[2]->in[23] mux_2level_size50[2]->in[24] mux_2level_size50[2]->in[25] mux_2level_size50[2]->in[26] mux_2level_size50[2]->in[27] mux_2level_size50[2]->in[28] mux_2level_size50[2]->in[29] mux_2level_size50[2]->in[30] mux_2level_size50[2]->in[31] mux_2level_size50[2]->in[32] mux_2level_size50[2]->in[33] mux_2level_size50[2]->in[34] mux_2level_size50[2]->in[35] mux_2level_size50[2]->in[36] mux_2level_size50[2]->in[37] mux_2level_size50[2]->in[38] mux_2level_size50[2]->in[39] mux_2level_size50[2]->in[40] mux_2level_size50[2]->in[41] mux_2level_size50[2]->in[42] mux_2level_size50[2]->in[43] mux_2level_size50[2]->in[44] mux_2level_size50[2]->in[45] mux_2level_size50[2]->in[46] mux_2level_size50[2]->in[47] mux_2level_size50[2]->in[48] mux_2level_size50[2]->in[49] mux_2level_size50[2]->out sram[32]->outb sram[32]->out sram[33]->out sram[33]->outb sram[34]->out sram[34]->outb sram[35]->out sram[35]->outb sram[36]->out sram[36]->outb sram[37]->out sram[37]->outb sram[38]->out sram[38]->outb sram[39]->out sram[39]->outb sram[40]->outb sram[40]->out sram[41]->out sram[41]->outb sram[42]->out sram[42]->outb sram[43]->out sram[43]->outb sram[44]->out sram[44]->outb sram[45]->out sram[45]->outb sram[46]->out sram[46]->outb sram[47]->out sram[47]->outb gvdd_mux_2level_size50[2] 0 mux_2level_size50
***** SRAM bits for MUX[2], level=2, select_path_id=0. *****
*****1000000010000000*****
Xsram[32] sram->in sram[32]->out sram[32]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[32]->out) 0
.nodeset V(sram[32]->outb) vsp
Xsram[33] sram->in sram[33]->out sram[33]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[33]->out) 0
.nodeset V(sram[33]->outb) vsp
Xsram[34] sram->in sram[34]->out sram[34]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[34]->out) 0
.nodeset V(sram[34]->outb) vsp
Xsram[35] sram->in sram[35]->out sram[35]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[35]->out) 0
.nodeset V(sram[35]->outb) vsp
Xsram[36] sram->in sram[36]->out sram[36]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[36]->out) 0
.nodeset V(sram[36]->outb) vsp
Xsram[37] sram->in sram[37]->out sram[37]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[37]->out) 0
.nodeset V(sram[37]->outb) vsp
Xsram[38] sram->in sram[38]->out sram[38]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[38]->out) 0
.nodeset V(sram[38]->outb) vsp
Xsram[39] sram->in sram[39]->out sram[39]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[39]->out) 0
.nodeset V(sram[39]->outb) vsp
Xsram[40] sram->in sram[40]->out sram[40]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[40]->out) 0
.nodeset V(sram[40]->outb) vsp
Xsram[41] sram->in sram[41]->out sram[41]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[41]->out) 0
.nodeset V(sram[41]->outb) vsp
Xsram[42] sram->in sram[42]->out sram[42]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[42]->out) 0
.nodeset V(sram[42]->outb) vsp
Xsram[43] sram->in sram[43]->out sram[43]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[43]->out) 0
.nodeset V(sram[43]->outb) vsp
Xsram[44] sram->in sram[44]->out sram[44]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[44]->out) 0
.nodeset V(sram[44]->outb) vsp
Xsram[45] sram->in sram[45]->out sram[45]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[45]->out) 0
.nodeset V(sram[45]->outb) vsp
Xsram[46] sram->in sram[46]->out sram[46]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[46]->out) 0
.nodeset V(sram[46]->outb) vsp
Xsram[47] sram->in sram[47]->out sram[47]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[47]->out) 0
.nodeset V(sram[47]->outb) vsp
***** Signal mux_2level_size50[2]->in[0] density = 0, probability=0.*****
Vmux_2level_size50[2]->in[0] mux_2level_size50[2]->in[0] 0
+  0
***** Signal mux_2level_size50[2]->in[1] density = 0, probability=0.*****
Vmux_2level_size50[2]->in[1] mux_2level_size50[2]->in[1] 0
+  0
***** Signal mux_2level_size50[2]->in[2] density = 0, probability=0.*****
Vmux_2level_size50[2]->in[2] mux_2level_size50[2]->in[2] 0
+  0
***** Signal mux_2level_size50[2]->in[3] density = 0, probability=0.*****
Vmux_2level_size50[2]->in[3] mux_2level_size50[2]->in[3] 0
+  0
***** Signal mux_2level_size50[2]->in[4] density = 0, probability=0.*****
Vmux_2level_size50[2]->in[4] mux_2level_size50[2]->in[4] 0
+  0
***** Signal mux_2level_size50[2]->in[5] density = 0, probability=0.*****
Vmux_2level_size50[2]->in[5] mux_2level_size50[2]->in[5] 0
+  0
***** Signal mux_2level_size50[2]->in[6] density = 0, probability=0.*****
Vmux_2level_size50[2]->in[6] mux_2level_size50[2]->in[6] 0
+  0
***** Signal mux_2level_size50[2]->in[7] density = 0, probability=0.*****
Vmux_2level_size50[2]->in[7] mux_2level_size50[2]->in[7] 0
+  0
***** Signal mux_2level_size50[2]->in[8] density = 0, probability=0.*****
Vmux_2level_size50[2]->in[8] mux_2level_size50[2]->in[8] 0
+  0
***** Signal mux_2level_size50[2]->in[9] density = 0, probability=0.*****
Vmux_2level_size50[2]->in[9] mux_2level_size50[2]->in[9] 0
+  0
***** Signal mux_2level_size50[2]->in[10] density = 0, probability=0.*****
Vmux_2level_size50[2]->in[10] mux_2level_size50[2]->in[10] 0
+  0
***** Signal mux_2level_size50[2]->in[11] density = 0, probability=0.*****
Vmux_2level_size50[2]->in[11] mux_2level_size50[2]->in[11] 0
+  0
***** Signal mux_2level_size50[2]->in[12] density = 0, probability=0.*****
Vmux_2level_size50[2]->in[12] mux_2level_size50[2]->in[12] 0
+  0
***** Signal mux_2level_size50[2]->in[13] density = 0, probability=0.*****
Vmux_2level_size50[2]->in[13] mux_2level_size50[2]->in[13] 0
+  0
***** Signal mux_2level_size50[2]->in[14] density = 0, probability=0.*****
Vmux_2level_size50[2]->in[14] mux_2level_size50[2]->in[14] 0
+  0
***** Signal mux_2level_size50[2]->in[15] density = 0, probability=0.*****
Vmux_2level_size50[2]->in[15] mux_2level_size50[2]->in[15] 0
+  0
***** Signal mux_2level_size50[2]->in[16] density = 0, probability=0.*****
Vmux_2level_size50[2]->in[16] mux_2level_size50[2]->in[16] 0
+  0
***** Signal mux_2level_size50[2]->in[17] density = 0, probability=0.*****
Vmux_2level_size50[2]->in[17] mux_2level_size50[2]->in[17] 0
+  0
***** Signal mux_2level_size50[2]->in[18] density = 0, probability=0.*****
Vmux_2level_size50[2]->in[18] mux_2level_size50[2]->in[18] 0
+  0
***** Signal mux_2level_size50[2]->in[19] density = 0, probability=0.*****
Vmux_2level_size50[2]->in[19] mux_2level_size50[2]->in[19] 0
+  0
***** Signal mux_2level_size50[2]->in[20] density = 0, probability=0.*****
Vmux_2level_size50[2]->in[20] mux_2level_size50[2]->in[20] 0
+  0
***** Signal mux_2level_size50[2]->in[21] density = 0, probability=0.*****
Vmux_2level_size50[2]->in[21] mux_2level_size50[2]->in[21] 0
+  0
***** Signal mux_2level_size50[2]->in[22] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[2]->in[22] mux_2level_size50[2]->in[22] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[2]->in[23] density = 0, probability=0.*****
Vmux_2level_size50[2]->in[23] mux_2level_size50[2]->in[23] 0
+  0
***** Signal mux_2level_size50[2]->in[24] density = 0, probability=0.*****
Vmux_2level_size50[2]->in[24] mux_2level_size50[2]->in[24] 0
+  0
***** Signal mux_2level_size50[2]->in[25] density = 0, probability=0.*****
Vmux_2level_size50[2]->in[25] mux_2level_size50[2]->in[25] 0
+  0
***** Signal mux_2level_size50[2]->in[26] density = 0, probability=0.*****
Vmux_2level_size50[2]->in[26] mux_2level_size50[2]->in[26] 0
+  0
***** Signal mux_2level_size50[2]->in[27] density = 0, probability=0.*****
Vmux_2level_size50[2]->in[27] mux_2level_size50[2]->in[27] 0
+  0
***** Signal mux_2level_size50[2]->in[28] density = 0, probability=0.*****
Vmux_2level_size50[2]->in[28] mux_2level_size50[2]->in[28] 0
+  0
***** Signal mux_2level_size50[2]->in[29] density = 0, probability=0.*****
Vmux_2level_size50[2]->in[29] mux_2level_size50[2]->in[29] 0
+  0
***** Signal mux_2level_size50[2]->in[30] density = 0, probability=0.*****
Vmux_2level_size50[2]->in[30] mux_2level_size50[2]->in[30] 0
+  0
***** Signal mux_2level_size50[2]->in[31] density = 0, probability=0.*****
Vmux_2level_size50[2]->in[31] mux_2level_size50[2]->in[31] 0
+  0
***** Signal mux_2level_size50[2]->in[32] density = 0, probability=0.*****
Vmux_2level_size50[2]->in[32] mux_2level_size50[2]->in[32] 0
+  0
***** Signal mux_2level_size50[2]->in[33] density = 0, probability=0.*****
Vmux_2level_size50[2]->in[33] mux_2level_size50[2]->in[33] 0
+  0
***** Signal mux_2level_size50[2]->in[34] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[2]->in[34] mux_2level_size50[2]->in[34] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[2]->in[35] density = 0, probability=0.*****
Vmux_2level_size50[2]->in[35] mux_2level_size50[2]->in[35] 0
+  0
***** Signal mux_2level_size50[2]->in[36] density = 0, probability=0.*****
Vmux_2level_size50[2]->in[36] mux_2level_size50[2]->in[36] 0
+  0
***** Signal mux_2level_size50[2]->in[37] density = 0, probability=0.*****
Vmux_2level_size50[2]->in[37] mux_2level_size50[2]->in[37] 0
+  0
***** Signal mux_2level_size50[2]->in[38] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[2]->in[38] mux_2level_size50[2]->in[38] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[2]->in[39] density = 0, probability=0.*****
Vmux_2level_size50[2]->in[39] mux_2level_size50[2]->in[39] 0
+  0
***** Signal mux_2level_size50[2]->in[40] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[2]->in[40] mux_2level_size50[2]->in[40] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[2]->in[41] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[2]->in[41] mux_2level_size50[2]->in[41] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[2]->in[42] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[2]->in[42] mux_2level_size50[2]->in[42] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[2]->in[43] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[2]->in[43] mux_2level_size50[2]->in[43] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[2]->in[44] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[2]->in[44] mux_2level_size50[2]->in[44] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[2]->in[45] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[2]->in[45] mux_2level_size50[2]->in[45] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[2]->in[46] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[2]->in[46] mux_2level_size50[2]->in[46] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[2]->in[47] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[2]->in[47] mux_2level_size50[2]->in[47] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[2]->in[48] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[2]->in[48] mux_2level_size50[2]->in[48] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[2]->in[49] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[2]->in[49] mux_2level_size50[2]->in[49] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
Vgvdd_mux_2level_size50[2] gvdd_mux_2level_size50[2] 0 vsp
***** Measurements *****
***** Rise delay *****
.meas tran delay_rise_idle_mux50[2]_in[2]_crossbar trig v(mux_2level_size50[2]->in[0]) val='input_thres_pct_rise*vsp' rise=1 td='clock_period'
+          targ v(mux_2level_size50[2]->out) val='output_thres_pct_rise*vsp' rise=1 td='clock_period'
***** Fall delay *****
.meas tran delay_fall_idle_mux50[2]_in[2]_crossbar trig v(mux_2level_size50[2]->in[0]) val='input_thres_pct_fall*vsp' fall=1 td='clock_period'
+          targ v(mux_2level_size50[2]->out) val='output_thres_pct_fall*vsp' fall=1 td='clock_period'
***** Rise timing period *****
.meas start_rise_idle_mux50[2]_in[2]_crossbar when v(mux_2level_size50[2]->in[0])='slew_lower_thres_pct_rise*vsp' rise=1 td='clock_period'
.meas tran switch_rise_idle_mux50[2]_in[2]_crossbar trig v(mux_2level_size50[2]->in[0]) val='slew_lower_thres_pct_rise*vsp' rise=1 td='clock_period'
+          targ v(mux_2level_size50[2]->out) val='slew_upper_thres_pct_rise*vsp' rise=1 td='clock_period'
***** Fall timing period *****
.meas start_fall_idle_mux50[2]_in[2]_crossbar when v(mux_2level_size50[2]->in[0])='slew_lower_thres_pct_fall*vsp' fall=1 td='clock_period'
.meas tran switch_fall_idle_mux50[2]_in[2]_crossbar trig v(mux_2level_size50[2]->in[0]) val='slew_lower_thres_pct_fall*vsp' fall=1 td='clock_period'
+          targ v(mux_2level_size50[2]->out) val='slew_upper_thres_pct_fall*vsp' fall=1 td='clock_period'
***** Leakage Power Measurement *****
.meas tran mux_2level_size50[2]_leakage_power avg p(Vgvdd_mux_2level_size50[2]) from=0 to='clock_period'
.meas tran leakage_idle_mux50[2]_in[2]_crossbar param='mux_2level_size50[2]_leakage_power'
***** Dynamic Power Measurement *****
.meas tran mux_2level_size50[2]_dynamic_power avg p(Vgvdd_mux_2level_size50[2]) from='clock_period' to='6*clock_period'
.meas tran mux_2level_size50[2]_energy_per_cycle param='mux_2level_size50[2]_dynamic_power*clock_period'
.meas tran dynamic_power_idle_mux50[2]_in[2]_crossbar  param='mux_2level_size50[2]_dynamic_power'
.meas tran energy_per_cycle_idle_mux50[2]_in[2]_crossbar  param='dynamic_power_idle_mux50[2]_in[2]_crossbar*clock_period'
.meas tran dynamic_rise_idle_mux50[2]_in[2]_crossbar avg p(Vgvdd_mux_2level_size50[2]) from='start_rise_idle_mux50[2]_in[2]_crossbar' to='start_rise_idle_mux50[2]_in[2]_crossbar+switch_rise_idle_mux50[2]_in[2]_crossbar'
.meas tran dynamic_fall_idle_mux50[2]_in[2]_crossbar avg p(Vgvdd_mux_2level_size50[2]) from='start_fall_idle_mux50[2]_in[2]_crossbar' to='start_fall_idle_mux50[2]_in[2]_crossbar+switch_fall_idle_mux50[2]_in[2]_crossbar'
.meas tran sum_leakage_power_mux[0to2]
+          param='sum_leakage_power_mux[0to1]+leakage_idle_mux50[2]_in[2]_crossbar'
.meas tran sum_energy_per_cycle_mux[0to2]
+          param='sum_energy_per_cycle_mux[0to1]+energy_per_cycle_idle_mux50[2]_in[2]_crossbar'
Xload_inv[2]_no0 mux_2level_size50[2]->out mux_2level_size50[2]->out_out[0] gvdd_load 0 inv size=5
.meas tran sum_leakage_power_pb_mux[0to2]
+          param='sum_leakage_power_pb_mux[0to1]+leakage_idle_mux50[2]_in[2]_crossbar'
.meas tran sum_energy_per_cycle_pb_mux[0to2]
+          param='sum_energy_per_cycle_pb_mux[0to1]+energy_per_cycle_idle_mux50[2]_in[2]_crossbar'
Xmux_2level_size50[3] mux_2level_size50[3]->in[0] mux_2level_size50[3]->in[1] mux_2level_size50[3]->in[2] mux_2level_size50[3]->in[3] mux_2level_size50[3]->in[4] mux_2level_size50[3]->in[5] mux_2level_size50[3]->in[6] mux_2level_size50[3]->in[7] mux_2level_size50[3]->in[8] mux_2level_size50[3]->in[9] mux_2level_size50[3]->in[10] mux_2level_size50[3]->in[11] mux_2level_size50[3]->in[12] mux_2level_size50[3]->in[13] mux_2level_size50[3]->in[14] mux_2level_size50[3]->in[15] mux_2level_size50[3]->in[16] mux_2level_size50[3]->in[17] mux_2level_size50[3]->in[18] mux_2level_size50[3]->in[19] mux_2level_size50[3]->in[20] mux_2level_size50[3]->in[21] mux_2level_size50[3]->in[22] mux_2level_size50[3]->in[23] mux_2level_size50[3]->in[24] mux_2level_size50[3]->in[25] mux_2level_size50[3]->in[26] mux_2level_size50[3]->in[27] mux_2level_size50[3]->in[28] mux_2level_size50[3]->in[29] mux_2level_size50[3]->in[30] mux_2level_size50[3]->in[31] mux_2level_size50[3]->in[32] mux_2level_size50[3]->in[33] mux_2level_size50[3]->in[34] mux_2level_size50[3]->in[35] mux_2level_size50[3]->in[36] mux_2level_size50[3]->in[37] mux_2level_size50[3]->in[38] mux_2level_size50[3]->in[39] mux_2level_size50[3]->in[40] mux_2level_size50[3]->in[41] mux_2level_size50[3]->in[42] mux_2level_size50[3]->in[43] mux_2level_size50[3]->in[44] mux_2level_size50[3]->in[45] mux_2level_size50[3]->in[46] mux_2level_size50[3]->in[47] mux_2level_size50[3]->in[48] mux_2level_size50[3]->in[49] mux_2level_size50[3]->out sram[48]->outb sram[48]->out sram[49]->out sram[49]->outb sram[50]->out sram[50]->outb sram[51]->out sram[51]->outb sram[52]->out sram[52]->outb sram[53]->out sram[53]->outb sram[54]->out sram[54]->outb sram[55]->out sram[55]->outb sram[56]->outb sram[56]->out sram[57]->out sram[57]->outb sram[58]->out sram[58]->outb sram[59]->out sram[59]->outb sram[60]->out sram[60]->outb sram[61]->out sram[61]->outb sram[62]->out sram[62]->outb sram[63]->out sram[63]->outb gvdd_mux_2level_size50[3] 0 mux_2level_size50
***** SRAM bits for MUX[3], level=2, select_path_id=0. *****
*****1000000010000000*****
Xsram[48] sram->in sram[48]->out sram[48]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[48]->out) 0
.nodeset V(sram[48]->outb) vsp
Xsram[49] sram->in sram[49]->out sram[49]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[49]->out) 0
.nodeset V(sram[49]->outb) vsp
Xsram[50] sram->in sram[50]->out sram[50]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[50]->out) 0
.nodeset V(sram[50]->outb) vsp
Xsram[51] sram->in sram[51]->out sram[51]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[51]->out) 0
.nodeset V(sram[51]->outb) vsp
Xsram[52] sram->in sram[52]->out sram[52]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[52]->out) 0
.nodeset V(sram[52]->outb) vsp
Xsram[53] sram->in sram[53]->out sram[53]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[53]->out) 0
.nodeset V(sram[53]->outb) vsp
Xsram[54] sram->in sram[54]->out sram[54]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[54]->out) 0
.nodeset V(sram[54]->outb) vsp
Xsram[55] sram->in sram[55]->out sram[55]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[55]->out) 0
.nodeset V(sram[55]->outb) vsp
Xsram[56] sram->in sram[56]->out sram[56]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[56]->out) 0
.nodeset V(sram[56]->outb) vsp
Xsram[57] sram->in sram[57]->out sram[57]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[57]->out) 0
.nodeset V(sram[57]->outb) vsp
Xsram[58] sram->in sram[58]->out sram[58]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[58]->out) 0
.nodeset V(sram[58]->outb) vsp
Xsram[59] sram->in sram[59]->out sram[59]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[59]->out) 0
.nodeset V(sram[59]->outb) vsp
Xsram[60] sram->in sram[60]->out sram[60]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[60]->out) 0
.nodeset V(sram[60]->outb) vsp
Xsram[61] sram->in sram[61]->out sram[61]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[61]->out) 0
.nodeset V(sram[61]->outb) vsp
Xsram[62] sram->in sram[62]->out sram[62]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[62]->out) 0
.nodeset V(sram[62]->outb) vsp
Xsram[63] sram->in sram[63]->out sram[63]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[63]->out) 0
.nodeset V(sram[63]->outb) vsp
***** Signal mux_2level_size50[3]->in[0] density = 0, probability=0.*****
Vmux_2level_size50[3]->in[0] mux_2level_size50[3]->in[0] 0
+  0
***** Signal mux_2level_size50[3]->in[1] density = 0, probability=0.*****
Vmux_2level_size50[3]->in[1] mux_2level_size50[3]->in[1] 0
+  0
***** Signal mux_2level_size50[3]->in[2] density = 0, probability=0.*****
Vmux_2level_size50[3]->in[2] mux_2level_size50[3]->in[2] 0
+  0
***** Signal mux_2level_size50[3]->in[3] density = 0, probability=0.*****
Vmux_2level_size50[3]->in[3] mux_2level_size50[3]->in[3] 0
+  0
***** Signal mux_2level_size50[3]->in[4] density = 0, probability=0.*****
Vmux_2level_size50[3]->in[4] mux_2level_size50[3]->in[4] 0
+  0
***** Signal mux_2level_size50[3]->in[5] density = 0, probability=0.*****
Vmux_2level_size50[3]->in[5] mux_2level_size50[3]->in[5] 0
+  0
***** Signal mux_2level_size50[3]->in[6] density = 0, probability=0.*****
Vmux_2level_size50[3]->in[6] mux_2level_size50[3]->in[6] 0
+  0
***** Signal mux_2level_size50[3]->in[7] density = 0, probability=0.*****
Vmux_2level_size50[3]->in[7] mux_2level_size50[3]->in[7] 0
+  0
***** Signal mux_2level_size50[3]->in[8] density = 0, probability=0.*****
Vmux_2level_size50[3]->in[8] mux_2level_size50[3]->in[8] 0
+  0
***** Signal mux_2level_size50[3]->in[9] density = 0, probability=0.*****
Vmux_2level_size50[3]->in[9] mux_2level_size50[3]->in[9] 0
+  0
***** Signal mux_2level_size50[3]->in[10] density = 0, probability=0.*****
Vmux_2level_size50[3]->in[10] mux_2level_size50[3]->in[10] 0
+  0
***** Signal mux_2level_size50[3]->in[11] density = 0, probability=0.*****
Vmux_2level_size50[3]->in[11] mux_2level_size50[3]->in[11] 0
+  0
***** Signal mux_2level_size50[3]->in[12] density = 0, probability=0.*****
Vmux_2level_size50[3]->in[12] mux_2level_size50[3]->in[12] 0
+  0
***** Signal mux_2level_size50[3]->in[13] density = 0, probability=0.*****
Vmux_2level_size50[3]->in[13] mux_2level_size50[3]->in[13] 0
+  0
***** Signal mux_2level_size50[3]->in[14] density = 0, probability=0.*****
Vmux_2level_size50[3]->in[14] mux_2level_size50[3]->in[14] 0
+  0
***** Signal mux_2level_size50[3]->in[15] density = 0, probability=0.*****
Vmux_2level_size50[3]->in[15] mux_2level_size50[3]->in[15] 0
+  0
***** Signal mux_2level_size50[3]->in[16] density = 0, probability=0.*****
Vmux_2level_size50[3]->in[16] mux_2level_size50[3]->in[16] 0
+  0
***** Signal mux_2level_size50[3]->in[17] density = 0, probability=0.*****
Vmux_2level_size50[3]->in[17] mux_2level_size50[3]->in[17] 0
+  0
***** Signal mux_2level_size50[3]->in[18] density = 0, probability=0.*****
Vmux_2level_size50[3]->in[18] mux_2level_size50[3]->in[18] 0
+  0
***** Signal mux_2level_size50[3]->in[19] density = 0, probability=0.*****
Vmux_2level_size50[3]->in[19] mux_2level_size50[3]->in[19] 0
+  0
***** Signal mux_2level_size50[3]->in[20] density = 0, probability=0.*****
Vmux_2level_size50[3]->in[20] mux_2level_size50[3]->in[20] 0
+  0
***** Signal mux_2level_size50[3]->in[21] density = 0, probability=0.*****
Vmux_2level_size50[3]->in[21] mux_2level_size50[3]->in[21] 0
+  0
***** Signal mux_2level_size50[3]->in[22] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[3]->in[22] mux_2level_size50[3]->in[22] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[3]->in[23] density = 0, probability=0.*****
Vmux_2level_size50[3]->in[23] mux_2level_size50[3]->in[23] 0
+  0
***** Signal mux_2level_size50[3]->in[24] density = 0, probability=0.*****
Vmux_2level_size50[3]->in[24] mux_2level_size50[3]->in[24] 0
+  0
***** Signal mux_2level_size50[3]->in[25] density = 0, probability=0.*****
Vmux_2level_size50[3]->in[25] mux_2level_size50[3]->in[25] 0
+  0
***** Signal mux_2level_size50[3]->in[26] density = 0, probability=0.*****
Vmux_2level_size50[3]->in[26] mux_2level_size50[3]->in[26] 0
+  0
***** Signal mux_2level_size50[3]->in[27] density = 0, probability=0.*****
Vmux_2level_size50[3]->in[27] mux_2level_size50[3]->in[27] 0
+  0
***** Signal mux_2level_size50[3]->in[28] density = 0, probability=0.*****
Vmux_2level_size50[3]->in[28] mux_2level_size50[3]->in[28] 0
+  0
***** Signal mux_2level_size50[3]->in[29] density = 0, probability=0.*****
Vmux_2level_size50[3]->in[29] mux_2level_size50[3]->in[29] 0
+  0
***** Signal mux_2level_size50[3]->in[30] density = 0, probability=0.*****
Vmux_2level_size50[3]->in[30] mux_2level_size50[3]->in[30] 0
+  0
***** Signal mux_2level_size50[3]->in[31] density = 0, probability=0.*****
Vmux_2level_size50[3]->in[31] mux_2level_size50[3]->in[31] 0
+  0
***** Signal mux_2level_size50[3]->in[32] density = 0, probability=0.*****
Vmux_2level_size50[3]->in[32] mux_2level_size50[3]->in[32] 0
+  0
***** Signal mux_2level_size50[3]->in[33] density = 0, probability=0.*****
Vmux_2level_size50[3]->in[33] mux_2level_size50[3]->in[33] 0
+  0
***** Signal mux_2level_size50[3]->in[34] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[3]->in[34] mux_2level_size50[3]->in[34] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[3]->in[35] density = 0, probability=0.*****
Vmux_2level_size50[3]->in[35] mux_2level_size50[3]->in[35] 0
+  0
***** Signal mux_2level_size50[3]->in[36] density = 0, probability=0.*****
Vmux_2level_size50[3]->in[36] mux_2level_size50[3]->in[36] 0
+  0
***** Signal mux_2level_size50[3]->in[37] density = 0, probability=0.*****
Vmux_2level_size50[3]->in[37] mux_2level_size50[3]->in[37] 0
+  0
***** Signal mux_2level_size50[3]->in[38] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[3]->in[38] mux_2level_size50[3]->in[38] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[3]->in[39] density = 0, probability=0.*****
Vmux_2level_size50[3]->in[39] mux_2level_size50[3]->in[39] 0
+  0
***** Signal mux_2level_size50[3]->in[40] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[3]->in[40] mux_2level_size50[3]->in[40] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[3]->in[41] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[3]->in[41] mux_2level_size50[3]->in[41] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[3]->in[42] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[3]->in[42] mux_2level_size50[3]->in[42] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[3]->in[43] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[3]->in[43] mux_2level_size50[3]->in[43] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[3]->in[44] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[3]->in[44] mux_2level_size50[3]->in[44] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[3]->in[45] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[3]->in[45] mux_2level_size50[3]->in[45] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[3]->in[46] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[3]->in[46] mux_2level_size50[3]->in[46] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[3]->in[47] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[3]->in[47] mux_2level_size50[3]->in[47] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[3]->in[48] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[3]->in[48] mux_2level_size50[3]->in[48] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[3]->in[49] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[3]->in[49] mux_2level_size50[3]->in[49] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
Vgvdd_mux_2level_size50[3] gvdd_mux_2level_size50[3] 0 vsp
***** Measurements *****
***** Rise delay *****
.meas tran delay_rise_idle_mux50[3]_in[3]_crossbar trig v(mux_2level_size50[3]->in[0]) val='input_thres_pct_rise*vsp' rise=1 td='clock_period'
+          targ v(mux_2level_size50[3]->out) val='output_thres_pct_rise*vsp' rise=1 td='clock_period'
***** Fall delay *****
.meas tran delay_fall_idle_mux50[3]_in[3]_crossbar trig v(mux_2level_size50[3]->in[0]) val='input_thres_pct_fall*vsp' fall=1 td='clock_period'
+          targ v(mux_2level_size50[3]->out) val='output_thres_pct_fall*vsp' fall=1 td='clock_period'
***** Rise timing period *****
.meas start_rise_idle_mux50[3]_in[3]_crossbar when v(mux_2level_size50[3]->in[0])='slew_lower_thres_pct_rise*vsp' rise=1 td='clock_period'
.meas tran switch_rise_idle_mux50[3]_in[3]_crossbar trig v(mux_2level_size50[3]->in[0]) val='slew_lower_thres_pct_rise*vsp' rise=1 td='clock_period'
+          targ v(mux_2level_size50[3]->out) val='slew_upper_thres_pct_rise*vsp' rise=1 td='clock_period'
***** Fall timing period *****
.meas start_fall_idle_mux50[3]_in[3]_crossbar when v(mux_2level_size50[3]->in[0])='slew_lower_thres_pct_fall*vsp' fall=1 td='clock_period'
.meas tran switch_fall_idle_mux50[3]_in[3]_crossbar trig v(mux_2level_size50[3]->in[0]) val='slew_lower_thres_pct_fall*vsp' fall=1 td='clock_period'
+          targ v(mux_2level_size50[3]->out) val='slew_upper_thres_pct_fall*vsp' fall=1 td='clock_period'
***** Leakage Power Measurement *****
.meas tran mux_2level_size50[3]_leakage_power avg p(Vgvdd_mux_2level_size50[3]) from=0 to='clock_period'
.meas tran leakage_idle_mux50[3]_in[3]_crossbar param='mux_2level_size50[3]_leakage_power'
***** Dynamic Power Measurement *****
.meas tran mux_2level_size50[3]_dynamic_power avg p(Vgvdd_mux_2level_size50[3]) from='clock_period' to='6*clock_period'
.meas tran mux_2level_size50[3]_energy_per_cycle param='mux_2level_size50[3]_dynamic_power*clock_period'
.meas tran dynamic_power_idle_mux50[3]_in[3]_crossbar  param='mux_2level_size50[3]_dynamic_power'
.meas tran energy_per_cycle_idle_mux50[3]_in[3]_crossbar  param='dynamic_power_idle_mux50[3]_in[3]_crossbar*clock_period'
.meas tran dynamic_rise_idle_mux50[3]_in[3]_crossbar avg p(Vgvdd_mux_2level_size50[3]) from='start_rise_idle_mux50[3]_in[3]_crossbar' to='start_rise_idle_mux50[3]_in[3]_crossbar+switch_rise_idle_mux50[3]_in[3]_crossbar'
.meas tran dynamic_fall_idle_mux50[3]_in[3]_crossbar avg p(Vgvdd_mux_2level_size50[3]) from='start_fall_idle_mux50[3]_in[3]_crossbar' to='start_fall_idle_mux50[3]_in[3]_crossbar+switch_fall_idle_mux50[3]_in[3]_crossbar'
.meas tran sum_leakage_power_mux[0to3]
+          param='sum_leakage_power_mux[0to2]+leakage_idle_mux50[3]_in[3]_crossbar'
.meas tran sum_energy_per_cycle_mux[0to3]
+          param='sum_energy_per_cycle_mux[0to2]+energy_per_cycle_idle_mux50[3]_in[3]_crossbar'
Xload_inv[3]_no0 mux_2level_size50[3]->out mux_2level_size50[3]->out_out[0] gvdd_load 0 inv size=5
.meas tran sum_leakage_power_pb_mux[0to3]
+          param='sum_leakage_power_pb_mux[0to2]+leakage_idle_mux50[3]_in[3]_crossbar'
.meas tran sum_energy_per_cycle_pb_mux[0to3]
+          param='sum_energy_per_cycle_pb_mux[0to2]+energy_per_cycle_idle_mux50[3]_in[3]_crossbar'
Xmux_2level_size50[4] mux_2level_size50[4]->in[0] mux_2level_size50[4]->in[1] mux_2level_size50[4]->in[2] mux_2level_size50[4]->in[3] mux_2level_size50[4]->in[4] mux_2level_size50[4]->in[5] mux_2level_size50[4]->in[6] mux_2level_size50[4]->in[7] mux_2level_size50[4]->in[8] mux_2level_size50[4]->in[9] mux_2level_size50[4]->in[10] mux_2level_size50[4]->in[11] mux_2level_size50[4]->in[12] mux_2level_size50[4]->in[13] mux_2level_size50[4]->in[14] mux_2level_size50[4]->in[15] mux_2level_size50[4]->in[16] mux_2level_size50[4]->in[17] mux_2level_size50[4]->in[18] mux_2level_size50[4]->in[19] mux_2level_size50[4]->in[20] mux_2level_size50[4]->in[21] mux_2level_size50[4]->in[22] mux_2level_size50[4]->in[23] mux_2level_size50[4]->in[24] mux_2level_size50[4]->in[25] mux_2level_size50[4]->in[26] mux_2level_size50[4]->in[27] mux_2level_size50[4]->in[28] mux_2level_size50[4]->in[29] mux_2level_size50[4]->in[30] mux_2level_size50[4]->in[31] mux_2level_size50[4]->in[32] mux_2level_size50[4]->in[33] mux_2level_size50[4]->in[34] mux_2level_size50[4]->in[35] mux_2level_size50[4]->in[36] mux_2level_size50[4]->in[37] mux_2level_size50[4]->in[38] mux_2level_size50[4]->in[39] mux_2level_size50[4]->in[40] mux_2level_size50[4]->in[41] mux_2level_size50[4]->in[42] mux_2level_size50[4]->in[43] mux_2level_size50[4]->in[44] mux_2level_size50[4]->in[45] mux_2level_size50[4]->in[46] mux_2level_size50[4]->in[47] mux_2level_size50[4]->in[48] mux_2level_size50[4]->in[49] mux_2level_size50[4]->out sram[64]->outb sram[64]->out sram[65]->out sram[65]->outb sram[66]->out sram[66]->outb sram[67]->out sram[67]->outb sram[68]->out sram[68]->outb sram[69]->out sram[69]->outb sram[70]->out sram[70]->outb sram[71]->out sram[71]->outb sram[72]->outb sram[72]->out sram[73]->out sram[73]->outb sram[74]->out sram[74]->outb sram[75]->out sram[75]->outb sram[76]->out sram[76]->outb sram[77]->out sram[77]->outb sram[78]->out sram[78]->outb sram[79]->out sram[79]->outb gvdd_mux_2level_size50[4] 0 mux_2level_size50
***** SRAM bits for MUX[4], level=2, select_path_id=0. *****
*****1000000010000000*****
Xsram[64] sram->in sram[64]->out sram[64]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[64]->out) 0
.nodeset V(sram[64]->outb) vsp
Xsram[65] sram->in sram[65]->out sram[65]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[65]->out) 0
.nodeset V(sram[65]->outb) vsp
Xsram[66] sram->in sram[66]->out sram[66]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[66]->out) 0
.nodeset V(sram[66]->outb) vsp
Xsram[67] sram->in sram[67]->out sram[67]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[67]->out) 0
.nodeset V(sram[67]->outb) vsp
Xsram[68] sram->in sram[68]->out sram[68]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[68]->out) 0
.nodeset V(sram[68]->outb) vsp
Xsram[69] sram->in sram[69]->out sram[69]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[69]->out) 0
.nodeset V(sram[69]->outb) vsp
Xsram[70] sram->in sram[70]->out sram[70]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[70]->out) 0
.nodeset V(sram[70]->outb) vsp
Xsram[71] sram->in sram[71]->out sram[71]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[71]->out) 0
.nodeset V(sram[71]->outb) vsp
Xsram[72] sram->in sram[72]->out sram[72]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[72]->out) 0
.nodeset V(sram[72]->outb) vsp
Xsram[73] sram->in sram[73]->out sram[73]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[73]->out) 0
.nodeset V(sram[73]->outb) vsp
Xsram[74] sram->in sram[74]->out sram[74]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[74]->out) 0
.nodeset V(sram[74]->outb) vsp
Xsram[75] sram->in sram[75]->out sram[75]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[75]->out) 0
.nodeset V(sram[75]->outb) vsp
Xsram[76] sram->in sram[76]->out sram[76]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[76]->out) 0
.nodeset V(sram[76]->outb) vsp
Xsram[77] sram->in sram[77]->out sram[77]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[77]->out) 0
.nodeset V(sram[77]->outb) vsp
Xsram[78] sram->in sram[78]->out sram[78]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[78]->out) 0
.nodeset V(sram[78]->outb) vsp
Xsram[79] sram->in sram[79]->out sram[79]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[79]->out) 0
.nodeset V(sram[79]->outb) vsp
***** Signal mux_2level_size50[4]->in[0] density = 0, probability=0.*****
Vmux_2level_size50[4]->in[0] mux_2level_size50[4]->in[0] 0
+  0
***** Signal mux_2level_size50[4]->in[1] density = 0, probability=0.*****
Vmux_2level_size50[4]->in[1] mux_2level_size50[4]->in[1] 0
+  0
***** Signal mux_2level_size50[4]->in[2] density = 0, probability=0.*****
Vmux_2level_size50[4]->in[2] mux_2level_size50[4]->in[2] 0
+  0
***** Signal mux_2level_size50[4]->in[3] density = 0, probability=0.*****
Vmux_2level_size50[4]->in[3] mux_2level_size50[4]->in[3] 0
+  0
***** Signal mux_2level_size50[4]->in[4] density = 0, probability=0.*****
Vmux_2level_size50[4]->in[4] mux_2level_size50[4]->in[4] 0
+  0
***** Signal mux_2level_size50[4]->in[5] density = 0, probability=0.*****
Vmux_2level_size50[4]->in[5] mux_2level_size50[4]->in[5] 0
+  0
***** Signal mux_2level_size50[4]->in[6] density = 0, probability=0.*****
Vmux_2level_size50[4]->in[6] mux_2level_size50[4]->in[6] 0
+  0
***** Signal mux_2level_size50[4]->in[7] density = 0, probability=0.*****
Vmux_2level_size50[4]->in[7] mux_2level_size50[4]->in[7] 0
+  0
***** Signal mux_2level_size50[4]->in[8] density = 0, probability=0.*****
Vmux_2level_size50[4]->in[8] mux_2level_size50[4]->in[8] 0
+  0
***** Signal mux_2level_size50[4]->in[9] density = 0, probability=0.*****
Vmux_2level_size50[4]->in[9] mux_2level_size50[4]->in[9] 0
+  0
***** Signal mux_2level_size50[4]->in[10] density = 0, probability=0.*****
Vmux_2level_size50[4]->in[10] mux_2level_size50[4]->in[10] 0
+  0
***** Signal mux_2level_size50[4]->in[11] density = 0, probability=0.*****
Vmux_2level_size50[4]->in[11] mux_2level_size50[4]->in[11] 0
+  0
***** Signal mux_2level_size50[4]->in[12] density = 0, probability=0.*****
Vmux_2level_size50[4]->in[12] mux_2level_size50[4]->in[12] 0
+  0
***** Signal mux_2level_size50[4]->in[13] density = 0, probability=0.*****
Vmux_2level_size50[4]->in[13] mux_2level_size50[4]->in[13] 0
+  0
***** Signal mux_2level_size50[4]->in[14] density = 0, probability=0.*****
Vmux_2level_size50[4]->in[14] mux_2level_size50[4]->in[14] 0
+  0
***** Signal mux_2level_size50[4]->in[15] density = 0, probability=0.*****
Vmux_2level_size50[4]->in[15] mux_2level_size50[4]->in[15] 0
+  0
***** Signal mux_2level_size50[4]->in[16] density = 0, probability=0.*****
Vmux_2level_size50[4]->in[16] mux_2level_size50[4]->in[16] 0
+  0
***** Signal mux_2level_size50[4]->in[17] density = 0, probability=0.*****
Vmux_2level_size50[4]->in[17] mux_2level_size50[4]->in[17] 0
+  0
***** Signal mux_2level_size50[4]->in[18] density = 0, probability=0.*****
Vmux_2level_size50[4]->in[18] mux_2level_size50[4]->in[18] 0
+  0
***** Signal mux_2level_size50[4]->in[19] density = 0, probability=0.*****
Vmux_2level_size50[4]->in[19] mux_2level_size50[4]->in[19] 0
+  0
***** Signal mux_2level_size50[4]->in[20] density = 0, probability=0.*****
Vmux_2level_size50[4]->in[20] mux_2level_size50[4]->in[20] 0
+  0
***** Signal mux_2level_size50[4]->in[21] density = 0, probability=0.*****
Vmux_2level_size50[4]->in[21] mux_2level_size50[4]->in[21] 0
+  0
***** Signal mux_2level_size50[4]->in[22] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[4]->in[22] mux_2level_size50[4]->in[22] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[4]->in[23] density = 0, probability=0.*****
Vmux_2level_size50[4]->in[23] mux_2level_size50[4]->in[23] 0
+  0
***** Signal mux_2level_size50[4]->in[24] density = 0, probability=0.*****
Vmux_2level_size50[4]->in[24] mux_2level_size50[4]->in[24] 0
+  0
***** Signal mux_2level_size50[4]->in[25] density = 0, probability=0.*****
Vmux_2level_size50[4]->in[25] mux_2level_size50[4]->in[25] 0
+  0
***** Signal mux_2level_size50[4]->in[26] density = 0, probability=0.*****
Vmux_2level_size50[4]->in[26] mux_2level_size50[4]->in[26] 0
+  0
***** Signal mux_2level_size50[4]->in[27] density = 0, probability=0.*****
Vmux_2level_size50[4]->in[27] mux_2level_size50[4]->in[27] 0
+  0
***** Signal mux_2level_size50[4]->in[28] density = 0, probability=0.*****
Vmux_2level_size50[4]->in[28] mux_2level_size50[4]->in[28] 0
+  0
***** Signal mux_2level_size50[4]->in[29] density = 0, probability=0.*****
Vmux_2level_size50[4]->in[29] mux_2level_size50[4]->in[29] 0
+  0
***** Signal mux_2level_size50[4]->in[30] density = 0, probability=0.*****
Vmux_2level_size50[4]->in[30] mux_2level_size50[4]->in[30] 0
+  0
***** Signal mux_2level_size50[4]->in[31] density = 0, probability=0.*****
Vmux_2level_size50[4]->in[31] mux_2level_size50[4]->in[31] 0
+  0
***** Signal mux_2level_size50[4]->in[32] density = 0, probability=0.*****
Vmux_2level_size50[4]->in[32] mux_2level_size50[4]->in[32] 0
+  0
***** Signal mux_2level_size50[4]->in[33] density = 0, probability=0.*****
Vmux_2level_size50[4]->in[33] mux_2level_size50[4]->in[33] 0
+  0
***** Signal mux_2level_size50[4]->in[34] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[4]->in[34] mux_2level_size50[4]->in[34] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[4]->in[35] density = 0, probability=0.*****
Vmux_2level_size50[4]->in[35] mux_2level_size50[4]->in[35] 0
+  0
***** Signal mux_2level_size50[4]->in[36] density = 0, probability=0.*****
Vmux_2level_size50[4]->in[36] mux_2level_size50[4]->in[36] 0
+  0
***** Signal mux_2level_size50[4]->in[37] density = 0, probability=0.*****
Vmux_2level_size50[4]->in[37] mux_2level_size50[4]->in[37] 0
+  0
***** Signal mux_2level_size50[4]->in[38] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[4]->in[38] mux_2level_size50[4]->in[38] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[4]->in[39] density = 0, probability=0.*****
Vmux_2level_size50[4]->in[39] mux_2level_size50[4]->in[39] 0
+  0
***** Signal mux_2level_size50[4]->in[40] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[4]->in[40] mux_2level_size50[4]->in[40] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[4]->in[41] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[4]->in[41] mux_2level_size50[4]->in[41] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[4]->in[42] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[4]->in[42] mux_2level_size50[4]->in[42] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[4]->in[43] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[4]->in[43] mux_2level_size50[4]->in[43] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[4]->in[44] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[4]->in[44] mux_2level_size50[4]->in[44] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[4]->in[45] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[4]->in[45] mux_2level_size50[4]->in[45] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[4]->in[46] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[4]->in[46] mux_2level_size50[4]->in[46] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[4]->in[47] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[4]->in[47] mux_2level_size50[4]->in[47] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[4]->in[48] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[4]->in[48] mux_2level_size50[4]->in[48] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[4]->in[49] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[4]->in[49] mux_2level_size50[4]->in[49] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
Vgvdd_mux_2level_size50[4] gvdd_mux_2level_size50[4] 0 vsp
***** Measurements *****
***** Rise delay *****
.meas tran delay_rise_idle_mux50[4]_in[4]_crossbar trig v(mux_2level_size50[4]->in[0]) val='input_thres_pct_rise*vsp' rise=1 td='clock_period'
+          targ v(mux_2level_size50[4]->out) val='output_thres_pct_rise*vsp' rise=1 td='clock_period'
***** Fall delay *****
.meas tran delay_fall_idle_mux50[4]_in[4]_crossbar trig v(mux_2level_size50[4]->in[0]) val='input_thres_pct_fall*vsp' fall=1 td='clock_period'
+          targ v(mux_2level_size50[4]->out) val='output_thres_pct_fall*vsp' fall=1 td='clock_period'
***** Rise timing period *****
.meas start_rise_idle_mux50[4]_in[4]_crossbar when v(mux_2level_size50[4]->in[0])='slew_lower_thres_pct_rise*vsp' rise=1 td='clock_period'
.meas tran switch_rise_idle_mux50[4]_in[4]_crossbar trig v(mux_2level_size50[4]->in[0]) val='slew_lower_thres_pct_rise*vsp' rise=1 td='clock_period'
+          targ v(mux_2level_size50[4]->out) val='slew_upper_thres_pct_rise*vsp' rise=1 td='clock_period'
***** Fall timing period *****
.meas start_fall_idle_mux50[4]_in[4]_crossbar when v(mux_2level_size50[4]->in[0])='slew_lower_thres_pct_fall*vsp' fall=1 td='clock_period'
.meas tran switch_fall_idle_mux50[4]_in[4]_crossbar trig v(mux_2level_size50[4]->in[0]) val='slew_lower_thres_pct_fall*vsp' fall=1 td='clock_period'
+          targ v(mux_2level_size50[4]->out) val='slew_upper_thres_pct_fall*vsp' fall=1 td='clock_period'
***** Leakage Power Measurement *****
.meas tran mux_2level_size50[4]_leakage_power avg p(Vgvdd_mux_2level_size50[4]) from=0 to='clock_period'
.meas tran leakage_idle_mux50[4]_in[4]_crossbar param='mux_2level_size50[4]_leakage_power'
***** Dynamic Power Measurement *****
.meas tran mux_2level_size50[4]_dynamic_power avg p(Vgvdd_mux_2level_size50[4]) from='clock_period' to='6*clock_period'
.meas tran mux_2level_size50[4]_energy_per_cycle param='mux_2level_size50[4]_dynamic_power*clock_period'
.meas tran dynamic_power_idle_mux50[4]_in[4]_crossbar  param='mux_2level_size50[4]_dynamic_power'
.meas tran energy_per_cycle_idle_mux50[4]_in[4]_crossbar  param='dynamic_power_idle_mux50[4]_in[4]_crossbar*clock_period'
.meas tran dynamic_rise_idle_mux50[4]_in[4]_crossbar avg p(Vgvdd_mux_2level_size50[4]) from='start_rise_idle_mux50[4]_in[4]_crossbar' to='start_rise_idle_mux50[4]_in[4]_crossbar+switch_rise_idle_mux50[4]_in[4]_crossbar'
.meas tran dynamic_fall_idle_mux50[4]_in[4]_crossbar avg p(Vgvdd_mux_2level_size50[4]) from='start_fall_idle_mux50[4]_in[4]_crossbar' to='start_fall_idle_mux50[4]_in[4]_crossbar+switch_fall_idle_mux50[4]_in[4]_crossbar'
.meas tran sum_leakage_power_mux[0to4]
+          param='sum_leakage_power_mux[0to3]+leakage_idle_mux50[4]_in[4]_crossbar'
.meas tran sum_energy_per_cycle_mux[0to4]
+          param='sum_energy_per_cycle_mux[0to3]+energy_per_cycle_idle_mux50[4]_in[4]_crossbar'
Xload_inv[4]_no0 mux_2level_size50[4]->out mux_2level_size50[4]->out_out[0] gvdd_load 0 inv size=5
.meas tran sum_leakage_power_pb_mux[0to4]
+          param='sum_leakage_power_pb_mux[0to3]+leakage_idle_mux50[4]_in[4]_crossbar'
.meas tran sum_energy_per_cycle_pb_mux[0to4]
+          param='sum_energy_per_cycle_pb_mux[0to3]+energy_per_cycle_idle_mux50[4]_in[4]_crossbar'
Xmux_2level_size50[5] mux_2level_size50[5]->in[0] mux_2level_size50[5]->in[1] mux_2level_size50[5]->in[2] mux_2level_size50[5]->in[3] mux_2level_size50[5]->in[4] mux_2level_size50[5]->in[5] mux_2level_size50[5]->in[6] mux_2level_size50[5]->in[7] mux_2level_size50[5]->in[8] mux_2level_size50[5]->in[9] mux_2level_size50[5]->in[10] mux_2level_size50[5]->in[11] mux_2level_size50[5]->in[12] mux_2level_size50[5]->in[13] mux_2level_size50[5]->in[14] mux_2level_size50[5]->in[15] mux_2level_size50[5]->in[16] mux_2level_size50[5]->in[17] mux_2level_size50[5]->in[18] mux_2level_size50[5]->in[19] mux_2level_size50[5]->in[20] mux_2level_size50[5]->in[21] mux_2level_size50[5]->in[22] mux_2level_size50[5]->in[23] mux_2level_size50[5]->in[24] mux_2level_size50[5]->in[25] mux_2level_size50[5]->in[26] mux_2level_size50[5]->in[27] mux_2level_size50[5]->in[28] mux_2level_size50[5]->in[29] mux_2level_size50[5]->in[30] mux_2level_size50[5]->in[31] mux_2level_size50[5]->in[32] mux_2level_size50[5]->in[33] mux_2level_size50[5]->in[34] mux_2level_size50[5]->in[35] mux_2level_size50[5]->in[36] mux_2level_size50[5]->in[37] mux_2level_size50[5]->in[38] mux_2level_size50[5]->in[39] mux_2level_size50[5]->in[40] mux_2level_size50[5]->in[41] mux_2level_size50[5]->in[42] mux_2level_size50[5]->in[43] mux_2level_size50[5]->in[44] mux_2level_size50[5]->in[45] mux_2level_size50[5]->in[46] mux_2level_size50[5]->in[47] mux_2level_size50[5]->in[48] mux_2level_size50[5]->in[49] mux_2level_size50[5]->out sram[80]->outb sram[80]->out sram[81]->out sram[81]->outb sram[82]->out sram[82]->outb sram[83]->out sram[83]->outb sram[84]->out sram[84]->outb sram[85]->out sram[85]->outb sram[86]->out sram[86]->outb sram[87]->out sram[87]->outb sram[88]->outb sram[88]->out sram[89]->out sram[89]->outb sram[90]->out sram[90]->outb sram[91]->out sram[91]->outb sram[92]->out sram[92]->outb sram[93]->out sram[93]->outb sram[94]->out sram[94]->outb sram[95]->out sram[95]->outb gvdd_mux_2level_size50[5] 0 mux_2level_size50
***** SRAM bits for MUX[5], level=2, select_path_id=0. *****
*****1000000010000000*****
Xsram[80] sram->in sram[80]->out sram[80]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[80]->out) 0
.nodeset V(sram[80]->outb) vsp
Xsram[81] sram->in sram[81]->out sram[81]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[81]->out) 0
.nodeset V(sram[81]->outb) vsp
Xsram[82] sram->in sram[82]->out sram[82]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[82]->out) 0
.nodeset V(sram[82]->outb) vsp
Xsram[83] sram->in sram[83]->out sram[83]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[83]->out) 0
.nodeset V(sram[83]->outb) vsp
Xsram[84] sram->in sram[84]->out sram[84]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[84]->out) 0
.nodeset V(sram[84]->outb) vsp
Xsram[85] sram->in sram[85]->out sram[85]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[85]->out) 0
.nodeset V(sram[85]->outb) vsp
Xsram[86] sram->in sram[86]->out sram[86]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[86]->out) 0
.nodeset V(sram[86]->outb) vsp
Xsram[87] sram->in sram[87]->out sram[87]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[87]->out) 0
.nodeset V(sram[87]->outb) vsp
Xsram[88] sram->in sram[88]->out sram[88]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[88]->out) 0
.nodeset V(sram[88]->outb) vsp
Xsram[89] sram->in sram[89]->out sram[89]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[89]->out) 0
.nodeset V(sram[89]->outb) vsp
Xsram[90] sram->in sram[90]->out sram[90]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[90]->out) 0
.nodeset V(sram[90]->outb) vsp
Xsram[91] sram->in sram[91]->out sram[91]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[91]->out) 0
.nodeset V(sram[91]->outb) vsp
Xsram[92] sram->in sram[92]->out sram[92]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[92]->out) 0
.nodeset V(sram[92]->outb) vsp
Xsram[93] sram->in sram[93]->out sram[93]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[93]->out) 0
.nodeset V(sram[93]->outb) vsp
Xsram[94] sram->in sram[94]->out sram[94]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[94]->out) 0
.nodeset V(sram[94]->outb) vsp
Xsram[95] sram->in sram[95]->out sram[95]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[95]->out) 0
.nodeset V(sram[95]->outb) vsp
***** Signal mux_2level_size50[5]->in[0] density = 0, probability=0.*****
Vmux_2level_size50[5]->in[0] mux_2level_size50[5]->in[0] 0
+  0
***** Signal mux_2level_size50[5]->in[1] density = 0, probability=0.*****
Vmux_2level_size50[5]->in[1] mux_2level_size50[5]->in[1] 0
+  0
***** Signal mux_2level_size50[5]->in[2] density = 0, probability=0.*****
Vmux_2level_size50[5]->in[2] mux_2level_size50[5]->in[2] 0
+  0
***** Signal mux_2level_size50[5]->in[3] density = 0, probability=0.*****
Vmux_2level_size50[5]->in[3] mux_2level_size50[5]->in[3] 0
+  0
***** Signal mux_2level_size50[5]->in[4] density = 0, probability=0.*****
Vmux_2level_size50[5]->in[4] mux_2level_size50[5]->in[4] 0
+  0
***** Signal mux_2level_size50[5]->in[5] density = 0, probability=0.*****
Vmux_2level_size50[5]->in[5] mux_2level_size50[5]->in[5] 0
+  0
***** Signal mux_2level_size50[5]->in[6] density = 0, probability=0.*****
Vmux_2level_size50[5]->in[6] mux_2level_size50[5]->in[6] 0
+  0
***** Signal mux_2level_size50[5]->in[7] density = 0, probability=0.*****
Vmux_2level_size50[5]->in[7] mux_2level_size50[5]->in[7] 0
+  0
***** Signal mux_2level_size50[5]->in[8] density = 0, probability=0.*****
Vmux_2level_size50[5]->in[8] mux_2level_size50[5]->in[8] 0
+  0
***** Signal mux_2level_size50[5]->in[9] density = 0, probability=0.*****
Vmux_2level_size50[5]->in[9] mux_2level_size50[5]->in[9] 0
+  0
***** Signal mux_2level_size50[5]->in[10] density = 0, probability=0.*****
Vmux_2level_size50[5]->in[10] mux_2level_size50[5]->in[10] 0
+  0
***** Signal mux_2level_size50[5]->in[11] density = 0, probability=0.*****
Vmux_2level_size50[5]->in[11] mux_2level_size50[5]->in[11] 0
+  0
***** Signal mux_2level_size50[5]->in[12] density = 0, probability=0.*****
Vmux_2level_size50[5]->in[12] mux_2level_size50[5]->in[12] 0
+  0
***** Signal mux_2level_size50[5]->in[13] density = 0, probability=0.*****
Vmux_2level_size50[5]->in[13] mux_2level_size50[5]->in[13] 0
+  0
***** Signal mux_2level_size50[5]->in[14] density = 0, probability=0.*****
Vmux_2level_size50[5]->in[14] mux_2level_size50[5]->in[14] 0
+  0
***** Signal mux_2level_size50[5]->in[15] density = 0, probability=0.*****
Vmux_2level_size50[5]->in[15] mux_2level_size50[5]->in[15] 0
+  0
***** Signal mux_2level_size50[5]->in[16] density = 0, probability=0.*****
Vmux_2level_size50[5]->in[16] mux_2level_size50[5]->in[16] 0
+  0
***** Signal mux_2level_size50[5]->in[17] density = 0, probability=0.*****
Vmux_2level_size50[5]->in[17] mux_2level_size50[5]->in[17] 0
+  0
***** Signal mux_2level_size50[5]->in[18] density = 0, probability=0.*****
Vmux_2level_size50[5]->in[18] mux_2level_size50[5]->in[18] 0
+  0
***** Signal mux_2level_size50[5]->in[19] density = 0, probability=0.*****
Vmux_2level_size50[5]->in[19] mux_2level_size50[5]->in[19] 0
+  0
***** Signal mux_2level_size50[5]->in[20] density = 0, probability=0.*****
Vmux_2level_size50[5]->in[20] mux_2level_size50[5]->in[20] 0
+  0
***** Signal mux_2level_size50[5]->in[21] density = 0, probability=0.*****
Vmux_2level_size50[5]->in[21] mux_2level_size50[5]->in[21] 0
+  0
***** Signal mux_2level_size50[5]->in[22] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[5]->in[22] mux_2level_size50[5]->in[22] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[5]->in[23] density = 0, probability=0.*****
Vmux_2level_size50[5]->in[23] mux_2level_size50[5]->in[23] 0
+  0
***** Signal mux_2level_size50[5]->in[24] density = 0, probability=0.*****
Vmux_2level_size50[5]->in[24] mux_2level_size50[5]->in[24] 0
+  0
***** Signal mux_2level_size50[5]->in[25] density = 0, probability=0.*****
Vmux_2level_size50[5]->in[25] mux_2level_size50[5]->in[25] 0
+  0
***** Signal mux_2level_size50[5]->in[26] density = 0, probability=0.*****
Vmux_2level_size50[5]->in[26] mux_2level_size50[5]->in[26] 0
+  0
***** Signal mux_2level_size50[5]->in[27] density = 0, probability=0.*****
Vmux_2level_size50[5]->in[27] mux_2level_size50[5]->in[27] 0
+  0
***** Signal mux_2level_size50[5]->in[28] density = 0, probability=0.*****
Vmux_2level_size50[5]->in[28] mux_2level_size50[5]->in[28] 0
+  0
***** Signal mux_2level_size50[5]->in[29] density = 0, probability=0.*****
Vmux_2level_size50[5]->in[29] mux_2level_size50[5]->in[29] 0
+  0
***** Signal mux_2level_size50[5]->in[30] density = 0, probability=0.*****
Vmux_2level_size50[5]->in[30] mux_2level_size50[5]->in[30] 0
+  0
***** Signal mux_2level_size50[5]->in[31] density = 0, probability=0.*****
Vmux_2level_size50[5]->in[31] mux_2level_size50[5]->in[31] 0
+  0
***** Signal mux_2level_size50[5]->in[32] density = 0, probability=0.*****
Vmux_2level_size50[5]->in[32] mux_2level_size50[5]->in[32] 0
+  0
***** Signal mux_2level_size50[5]->in[33] density = 0, probability=0.*****
Vmux_2level_size50[5]->in[33] mux_2level_size50[5]->in[33] 0
+  0
***** Signal mux_2level_size50[5]->in[34] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[5]->in[34] mux_2level_size50[5]->in[34] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[5]->in[35] density = 0, probability=0.*****
Vmux_2level_size50[5]->in[35] mux_2level_size50[5]->in[35] 0
+  0
***** Signal mux_2level_size50[5]->in[36] density = 0, probability=0.*****
Vmux_2level_size50[5]->in[36] mux_2level_size50[5]->in[36] 0
+  0
***** Signal mux_2level_size50[5]->in[37] density = 0, probability=0.*****
Vmux_2level_size50[5]->in[37] mux_2level_size50[5]->in[37] 0
+  0
***** Signal mux_2level_size50[5]->in[38] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[5]->in[38] mux_2level_size50[5]->in[38] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[5]->in[39] density = 0, probability=0.*****
Vmux_2level_size50[5]->in[39] mux_2level_size50[5]->in[39] 0
+  0
***** Signal mux_2level_size50[5]->in[40] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[5]->in[40] mux_2level_size50[5]->in[40] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[5]->in[41] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[5]->in[41] mux_2level_size50[5]->in[41] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[5]->in[42] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[5]->in[42] mux_2level_size50[5]->in[42] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[5]->in[43] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[5]->in[43] mux_2level_size50[5]->in[43] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[5]->in[44] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[5]->in[44] mux_2level_size50[5]->in[44] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[5]->in[45] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[5]->in[45] mux_2level_size50[5]->in[45] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[5]->in[46] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[5]->in[46] mux_2level_size50[5]->in[46] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[5]->in[47] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[5]->in[47] mux_2level_size50[5]->in[47] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[5]->in[48] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[5]->in[48] mux_2level_size50[5]->in[48] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[5]->in[49] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[5]->in[49] mux_2level_size50[5]->in[49] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
Vgvdd_mux_2level_size50[5] gvdd_mux_2level_size50[5] 0 vsp
***** Measurements *****
***** Rise delay *****
.meas tran delay_rise_idle_mux50[5]_in[5]_crossbar trig v(mux_2level_size50[5]->in[0]) val='input_thres_pct_rise*vsp' rise=1 td='clock_period'
+          targ v(mux_2level_size50[5]->out) val='output_thres_pct_rise*vsp' rise=1 td='clock_period'
***** Fall delay *****
.meas tran delay_fall_idle_mux50[5]_in[5]_crossbar trig v(mux_2level_size50[5]->in[0]) val='input_thres_pct_fall*vsp' fall=1 td='clock_period'
+          targ v(mux_2level_size50[5]->out) val='output_thres_pct_fall*vsp' fall=1 td='clock_period'
***** Rise timing period *****
.meas start_rise_idle_mux50[5]_in[5]_crossbar when v(mux_2level_size50[5]->in[0])='slew_lower_thres_pct_rise*vsp' rise=1 td='clock_period'
.meas tran switch_rise_idle_mux50[5]_in[5]_crossbar trig v(mux_2level_size50[5]->in[0]) val='slew_lower_thres_pct_rise*vsp' rise=1 td='clock_period'
+          targ v(mux_2level_size50[5]->out) val='slew_upper_thres_pct_rise*vsp' rise=1 td='clock_period'
***** Fall timing period *****
.meas start_fall_idle_mux50[5]_in[5]_crossbar when v(mux_2level_size50[5]->in[0])='slew_lower_thres_pct_fall*vsp' fall=1 td='clock_period'
.meas tran switch_fall_idle_mux50[5]_in[5]_crossbar trig v(mux_2level_size50[5]->in[0]) val='slew_lower_thres_pct_fall*vsp' fall=1 td='clock_period'
+          targ v(mux_2level_size50[5]->out) val='slew_upper_thres_pct_fall*vsp' fall=1 td='clock_period'
***** Leakage Power Measurement *****
.meas tran mux_2level_size50[5]_leakage_power avg p(Vgvdd_mux_2level_size50[5]) from=0 to='clock_period'
.meas tran leakage_idle_mux50[5]_in[5]_crossbar param='mux_2level_size50[5]_leakage_power'
***** Dynamic Power Measurement *****
.meas tran mux_2level_size50[5]_dynamic_power avg p(Vgvdd_mux_2level_size50[5]) from='clock_period' to='6*clock_period'
.meas tran mux_2level_size50[5]_energy_per_cycle param='mux_2level_size50[5]_dynamic_power*clock_period'
.meas tran dynamic_power_idle_mux50[5]_in[5]_crossbar  param='mux_2level_size50[5]_dynamic_power'
.meas tran energy_per_cycle_idle_mux50[5]_in[5]_crossbar  param='dynamic_power_idle_mux50[5]_in[5]_crossbar*clock_period'
.meas tran dynamic_rise_idle_mux50[5]_in[5]_crossbar avg p(Vgvdd_mux_2level_size50[5]) from='start_rise_idle_mux50[5]_in[5]_crossbar' to='start_rise_idle_mux50[5]_in[5]_crossbar+switch_rise_idle_mux50[5]_in[5]_crossbar'
.meas tran dynamic_fall_idle_mux50[5]_in[5]_crossbar avg p(Vgvdd_mux_2level_size50[5]) from='start_fall_idle_mux50[5]_in[5]_crossbar' to='start_fall_idle_mux50[5]_in[5]_crossbar+switch_fall_idle_mux50[5]_in[5]_crossbar'
.meas tran sum_leakage_power_mux[0to5]
+          param='sum_leakage_power_mux[0to4]+leakage_idle_mux50[5]_in[5]_crossbar'
.meas tran sum_energy_per_cycle_mux[0to5]
+          param='sum_energy_per_cycle_mux[0to4]+energy_per_cycle_idle_mux50[5]_in[5]_crossbar'
Xload_inv[5]_no0 mux_2level_size50[5]->out mux_2level_size50[5]->out_out[0] gvdd_load 0 inv size=5
.meas tran sum_leakage_power_pb_mux[0to5]
+          param='sum_leakage_power_pb_mux[0to4]+leakage_idle_mux50[5]_in[5]_crossbar'
.meas tran sum_energy_per_cycle_pb_mux[0to5]
+          param='sum_energy_per_cycle_pb_mux[0to4]+energy_per_cycle_idle_mux50[5]_in[5]_crossbar'
Xmux_2level_size50[6] mux_2level_size50[6]->in[0] mux_2level_size50[6]->in[1] mux_2level_size50[6]->in[2] mux_2level_size50[6]->in[3] mux_2level_size50[6]->in[4] mux_2level_size50[6]->in[5] mux_2level_size50[6]->in[6] mux_2level_size50[6]->in[7] mux_2level_size50[6]->in[8] mux_2level_size50[6]->in[9] mux_2level_size50[6]->in[10] mux_2level_size50[6]->in[11] mux_2level_size50[6]->in[12] mux_2level_size50[6]->in[13] mux_2level_size50[6]->in[14] mux_2level_size50[6]->in[15] mux_2level_size50[6]->in[16] mux_2level_size50[6]->in[17] mux_2level_size50[6]->in[18] mux_2level_size50[6]->in[19] mux_2level_size50[6]->in[20] mux_2level_size50[6]->in[21] mux_2level_size50[6]->in[22] mux_2level_size50[6]->in[23] mux_2level_size50[6]->in[24] mux_2level_size50[6]->in[25] mux_2level_size50[6]->in[26] mux_2level_size50[6]->in[27] mux_2level_size50[6]->in[28] mux_2level_size50[6]->in[29] mux_2level_size50[6]->in[30] mux_2level_size50[6]->in[31] mux_2level_size50[6]->in[32] mux_2level_size50[6]->in[33] mux_2level_size50[6]->in[34] mux_2level_size50[6]->in[35] mux_2level_size50[6]->in[36] mux_2level_size50[6]->in[37] mux_2level_size50[6]->in[38] mux_2level_size50[6]->in[39] mux_2level_size50[6]->in[40] mux_2level_size50[6]->in[41] mux_2level_size50[6]->in[42] mux_2level_size50[6]->in[43] mux_2level_size50[6]->in[44] mux_2level_size50[6]->in[45] mux_2level_size50[6]->in[46] mux_2level_size50[6]->in[47] mux_2level_size50[6]->in[48] mux_2level_size50[6]->in[49] mux_2level_size50[6]->out sram[96]->outb sram[96]->out sram[97]->out sram[97]->outb sram[98]->out sram[98]->outb sram[99]->out sram[99]->outb sram[100]->out sram[100]->outb sram[101]->out sram[101]->outb sram[102]->out sram[102]->outb sram[103]->out sram[103]->outb sram[104]->outb sram[104]->out sram[105]->out sram[105]->outb sram[106]->out sram[106]->outb sram[107]->out sram[107]->outb sram[108]->out sram[108]->outb sram[109]->out sram[109]->outb sram[110]->out sram[110]->outb sram[111]->out sram[111]->outb gvdd_mux_2level_size50[6] 0 mux_2level_size50
***** SRAM bits for MUX[6], level=2, select_path_id=0. *****
*****1000000010000000*****
Xsram[96] sram->in sram[96]->out sram[96]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[96]->out) 0
.nodeset V(sram[96]->outb) vsp
Xsram[97] sram->in sram[97]->out sram[97]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[97]->out) 0
.nodeset V(sram[97]->outb) vsp
Xsram[98] sram->in sram[98]->out sram[98]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[98]->out) 0
.nodeset V(sram[98]->outb) vsp
Xsram[99] sram->in sram[99]->out sram[99]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[99]->out) 0
.nodeset V(sram[99]->outb) vsp
Xsram[100] sram->in sram[100]->out sram[100]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[100]->out) 0
.nodeset V(sram[100]->outb) vsp
Xsram[101] sram->in sram[101]->out sram[101]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[101]->out) 0
.nodeset V(sram[101]->outb) vsp
Xsram[102] sram->in sram[102]->out sram[102]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[102]->out) 0
.nodeset V(sram[102]->outb) vsp
Xsram[103] sram->in sram[103]->out sram[103]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[103]->out) 0
.nodeset V(sram[103]->outb) vsp
Xsram[104] sram->in sram[104]->out sram[104]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[104]->out) 0
.nodeset V(sram[104]->outb) vsp
Xsram[105] sram->in sram[105]->out sram[105]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[105]->out) 0
.nodeset V(sram[105]->outb) vsp
Xsram[106] sram->in sram[106]->out sram[106]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[106]->out) 0
.nodeset V(sram[106]->outb) vsp
Xsram[107] sram->in sram[107]->out sram[107]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[107]->out) 0
.nodeset V(sram[107]->outb) vsp
Xsram[108] sram->in sram[108]->out sram[108]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[108]->out) 0
.nodeset V(sram[108]->outb) vsp
Xsram[109] sram->in sram[109]->out sram[109]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[109]->out) 0
.nodeset V(sram[109]->outb) vsp
Xsram[110] sram->in sram[110]->out sram[110]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[110]->out) 0
.nodeset V(sram[110]->outb) vsp
Xsram[111] sram->in sram[111]->out sram[111]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[111]->out) 0
.nodeset V(sram[111]->outb) vsp
***** Signal mux_2level_size50[6]->in[0] density = 0, probability=0.*****
Vmux_2level_size50[6]->in[0] mux_2level_size50[6]->in[0] 0
+  0
***** Signal mux_2level_size50[6]->in[1] density = 0, probability=0.*****
Vmux_2level_size50[6]->in[1] mux_2level_size50[6]->in[1] 0
+  0
***** Signal mux_2level_size50[6]->in[2] density = 0, probability=0.*****
Vmux_2level_size50[6]->in[2] mux_2level_size50[6]->in[2] 0
+  0
***** Signal mux_2level_size50[6]->in[3] density = 0, probability=0.*****
Vmux_2level_size50[6]->in[3] mux_2level_size50[6]->in[3] 0
+  0
***** Signal mux_2level_size50[6]->in[4] density = 0, probability=0.*****
Vmux_2level_size50[6]->in[4] mux_2level_size50[6]->in[4] 0
+  0
***** Signal mux_2level_size50[6]->in[5] density = 0, probability=0.*****
Vmux_2level_size50[6]->in[5] mux_2level_size50[6]->in[5] 0
+  0
***** Signal mux_2level_size50[6]->in[6] density = 0, probability=0.*****
Vmux_2level_size50[6]->in[6] mux_2level_size50[6]->in[6] 0
+  0
***** Signal mux_2level_size50[6]->in[7] density = 0, probability=0.*****
Vmux_2level_size50[6]->in[7] mux_2level_size50[6]->in[7] 0
+  0
***** Signal mux_2level_size50[6]->in[8] density = 0, probability=0.*****
Vmux_2level_size50[6]->in[8] mux_2level_size50[6]->in[8] 0
+  0
***** Signal mux_2level_size50[6]->in[9] density = 0, probability=0.*****
Vmux_2level_size50[6]->in[9] mux_2level_size50[6]->in[9] 0
+  0
***** Signal mux_2level_size50[6]->in[10] density = 0, probability=0.*****
Vmux_2level_size50[6]->in[10] mux_2level_size50[6]->in[10] 0
+  0
***** Signal mux_2level_size50[6]->in[11] density = 0, probability=0.*****
Vmux_2level_size50[6]->in[11] mux_2level_size50[6]->in[11] 0
+  0
***** Signal mux_2level_size50[6]->in[12] density = 0, probability=0.*****
Vmux_2level_size50[6]->in[12] mux_2level_size50[6]->in[12] 0
+  0
***** Signal mux_2level_size50[6]->in[13] density = 0, probability=0.*****
Vmux_2level_size50[6]->in[13] mux_2level_size50[6]->in[13] 0
+  0
***** Signal mux_2level_size50[6]->in[14] density = 0, probability=0.*****
Vmux_2level_size50[6]->in[14] mux_2level_size50[6]->in[14] 0
+  0
***** Signal mux_2level_size50[6]->in[15] density = 0, probability=0.*****
Vmux_2level_size50[6]->in[15] mux_2level_size50[6]->in[15] 0
+  0
***** Signal mux_2level_size50[6]->in[16] density = 0, probability=0.*****
Vmux_2level_size50[6]->in[16] mux_2level_size50[6]->in[16] 0
+  0
***** Signal mux_2level_size50[6]->in[17] density = 0, probability=0.*****
Vmux_2level_size50[6]->in[17] mux_2level_size50[6]->in[17] 0
+  0
***** Signal mux_2level_size50[6]->in[18] density = 0, probability=0.*****
Vmux_2level_size50[6]->in[18] mux_2level_size50[6]->in[18] 0
+  0
***** Signal mux_2level_size50[6]->in[19] density = 0, probability=0.*****
Vmux_2level_size50[6]->in[19] mux_2level_size50[6]->in[19] 0
+  0
***** Signal mux_2level_size50[6]->in[20] density = 0, probability=0.*****
Vmux_2level_size50[6]->in[20] mux_2level_size50[6]->in[20] 0
+  0
***** Signal mux_2level_size50[6]->in[21] density = 0, probability=0.*****
Vmux_2level_size50[6]->in[21] mux_2level_size50[6]->in[21] 0
+  0
***** Signal mux_2level_size50[6]->in[22] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[6]->in[22] mux_2level_size50[6]->in[22] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[6]->in[23] density = 0, probability=0.*****
Vmux_2level_size50[6]->in[23] mux_2level_size50[6]->in[23] 0
+  0
***** Signal mux_2level_size50[6]->in[24] density = 0, probability=0.*****
Vmux_2level_size50[6]->in[24] mux_2level_size50[6]->in[24] 0
+  0
***** Signal mux_2level_size50[6]->in[25] density = 0, probability=0.*****
Vmux_2level_size50[6]->in[25] mux_2level_size50[6]->in[25] 0
+  0
***** Signal mux_2level_size50[6]->in[26] density = 0, probability=0.*****
Vmux_2level_size50[6]->in[26] mux_2level_size50[6]->in[26] 0
+  0
***** Signal mux_2level_size50[6]->in[27] density = 0, probability=0.*****
Vmux_2level_size50[6]->in[27] mux_2level_size50[6]->in[27] 0
+  0
***** Signal mux_2level_size50[6]->in[28] density = 0, probability=0.*****
Vmux_2level_size50[6]->in[28] mux_2level_size50[6]->in[28] 0
+  0
***** Signal mux_2level_size50[6]->in[29] density = 0, probability=0.*****
Vmux_2level_size50[6]->in[29] mux_2level_size50[6]->in[29] 0
+  0
***** Signal mux_2level_size50[6]->in[30] density = 0, probability=0.*****
Vmux_2level_size50[6]->in[30] mux_2level_size50[6]->in[30] 0
+  0
***** Signal mux_2level_size50[6]->in[31] density = 0, probability=0.*****
Vmux_2level_size50[6]->in[31] mux_2level_size50[6]->in[31] 0
+  0
***** Signal mux_2level_size50[6]->in[32] density = 0, probability=0.*****
Vmux_2level_size50[6]->in[32] mux_2level_size50[6]->in[32] 0
+  0
***** Signal mux_2level_size50[6]->in[33] density = 0, probability=0.*****
Vmux_2level_size50[6]->in[33] mux_2level_size50[6]->in[33] 0
+  0
***** Signal mux_2level_size50[6]->in[34] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[6]->in[34] mux_2level_size50[6]->in[34] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[6]->in[35] density = 0, probability=0.*****
Vmux_2level_size50[6]->in[35] mux_2level_size50[6]->in[35] 0
+  0
***** Signal mux_2level_size50[6]->in[36] density = 0, probability=0.*****
Vmux_2level_size50[6]->in[36] mux_2level_size50[6]->in[36] 0
+  0
***** Signal mux_2level_size50[6]->in[37] density = 0, probability=0.*****
Vmux_2level_size50[6]->in[37] mux_2level_size50[6]->in[37] 0
+  0
***** Signal mux_2level_size50[6]->in[38] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[6]->in[38] mux_2level_size50[6]->in[38] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[6]->in[39] density = 0, probability=0.*****
Vmux_2level_size50[6]->in[39] mux_2level_size50[6]->in[39] 0
+  0
***** Signal mux_2level_size50[6]->in[40] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[6]->in[40] mux_2level_size50[6]->in[40] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[6]->in[41] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[6]->in[41] mux_2level_size50[6]->in[41] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[6]->in[42] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[6]->in[42] mux_2level_size50[6]->in[42] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[6]->in[43] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[6]->in[43] mux_2level_size50[6]->in[43] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[6]->in[44] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[6]->in[44] mux_2level_size50[6]->in[44] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[6]->in[45] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[6]->in[45] mux_2level_size50[6]->in[45] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[6]->in[46] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[6]->in[46] mux_2level_size50[6]->in[46] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[6]->in[47] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[6]->in[47] mux_2level_size50[6]->in[47] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[6]->in[48] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[6]->in[48] mux_2level_size50[6]->in[48] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[6]->in[49] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[6]->in[49] mux_2level_size50[6]->in[49] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
Vgvdd_mux_2level_size50[6] gvdd_mux_2level_size50[6] 0 vsp
***** Measurements *****
***** Rise delay *****
.meas tran delay_rise_idle_mux50[6]_in[0]_crossbar trig v(mux_2level_size50[6]->in[0]) val='input_thres_pct_rise*vsp' rise=1 td='clock_period'
+          targ v(mux_2level_size50[6]->out) val='output_thres_pct_rise*vsp' rise=1 td='clock_period'
***** Fall delay *****
.meas tran delay_fall_idle_mux50[6]_in[0]_crossbar trig v(mux_2level_size50[6]->in[0]) val='input_thres_pct_fall*vsp' fall=1 td='clock_period'
+          targ v(mux_2level_size50[6]->out) val='output_thres_pct_fall*vsp' fall=1 td='clock_period'
***** Rise timing period *****
.meas start_rise_idle_mux50[6]_in[0]_crossbar when v(mux_2level_size50[6]->in[0])='slew_lower_thres_pct_rise*vsp' rise=1 td='clock_period'
.meas tran switch_rise_idle_mux50[6]_in[0]_crossbar trig v(mux_2level_size50[6]->in[0]) val='slew_lower_thres_pct_rise*vsp' rise=1 td='clock_period'
+          targ v(mux_2level_size50[6]->out) val='slew_upper_thres_pct_rise*vsp' rise=1 td='clock_period'
***** Fall timing period *****
.meas start_fall_idle_mux50[6]_in[0]_crossbar when v(mux_2level_size50[6]->in[0])='slew_lower_thres_pct_fall*vsp' fall=1 td='clock_period'
.meas tran switch_fall_idle_mux50[6]_in[0]_crossbar trig v(mux_2level_size50[6]->in[0]) val='slew_lower_thres_pct_fall*vsp' fall=1 td='clock_period'
+          targ v(mux_2level_size50[6]->out) val='slew_upper_thres_pct_fall*vsp' fall=1 td='clock_period'
***** Leakage Power Measurement *****
.meas tran mux_2level_size50[6]_leakage_power avg p(Vgvdd_mux_2level_size50[6]) from=0 to='clock_period'
.meas tran leakage_idle_mux50[6]_in[0]_crossbar param='mux_2level_size50[6]_leakage_power'
***** Dynamic Power Measurement *****
.meas tran mux_2level_size50[6]_dynamic_power avg p(Vgvdd_mux_2level_size50[6]) from='clock_period' to='6*clock_period'
.meas tran mux_2level_size50[6]_energy_per_cycle param='mux_2level_size50[6]_dynamic_power*clock_period'
.meas tran dynamic_power_idle_mux50[6]_in[0]_crossbar  param='mux_2level_size50[6]_dynamic_power'
.meas tran energy_per_cycle_idle_mux50[6]_in[0]_crossbar  param='dynamic_power_idle_mux50[6]_in[0]_crossbar*clock_period'
.meas tran dynamic_rise_idle_mux50[6]_in[0]_crossbar avg p(Vgvdd_mux_2level_size50[6]) from='start_rise_idle_mux50[6]_in[0]_crossbar' to='start_rise_idle_mux50[6]_in[0]_crossbar+switch_rise_idle_mux50[6]_in[0]_crossbar'
.meas tran dynamic_fall_idle_mux50[6]_in[0]_crossbar avg p(Vgvdd_mux_2level_size50[6]) from='start_fall_idle_mux50[6]_in[0]_crossbar' to='start_fall_idle_mux50[6]_in[0]_crossbar+switch_fall_idle_mux50[6]_in[0]_crossbar'
.meas tran sum_leakage_power_mux[0to6]
+          param='sum_leakage_power_mux[0to5]+leakage_idle_mux50[6]_in[0]_crossbar'
.meas tran sum_energy_per_cycle_mux[0to6]
+          param='sum_energy_per_cycle_mux[0to5]+energy_per_cycle_idle_mux50[6]_in[0]_crossbar'
Xload_inv[6]_no0 mux_2level_size50[6]->out mux_2level_size50[6]->out_out[0] gvdd_load 0 inv size=5
.meas tran sum_leakage_power_pb_mux[0to6]
+          param='sum_leakage_power_pb_mux[0to5]+leakage_idle_mux50[6]_in[0]_crossbar'
.meas tran sum_energy_per_cycle_pb_mux[0to6]
+          param='sum_energy_per_cycle_pb_mux[0to5]+energy_per_cycle_idle_mux50[6]_in[0]_crossbar'
Xmux_2level_size50[7] mux_2level_size50[7]->in[0] mux_2level_size50[7]->in[1] mux_2level_size50[7]->in[2] mux_2level_size50[7]->in[3] mux_2level_size50[7]->in[4] mux_2level_size50[7]->in[5] mux_2level_size50[7]->in[6] mux_2level_size50[7]->in[7] mux_2level_size50[7]->in[8] mux_2level_size50[7]->in[9] mux_2level_size50[7]->in[10] mux_2level_size50[7]->in[11] mux_2level_size50[7]->in[12] mux_2level_size50[7]->in[13] mux_2level_size50[7]->in[14] mux_2level_size50[7]->in[15] mux_2level_size50[7]->in[16] mux_2level_size50[7]->in[17] mux_2level_size50[7]->in[18] mux_2level_size50[7]->in[19] mux_2level_size50[7]->in[20] mux_2level_size50[7]->in[21] mux_2level_size50[7]->in[22] mux_2level_size50[7]->in[23] mux_2level_size50[7]->in[24] mux_2level_size50[7]->in[25] mux_2level_size50[7]->in[26] mux_2level_size50[7]->in[27] mux_2level_size50[7]->in[28] mux_2level_size50[7]->in[29] mux_2level_size50[7]->in[30] mux_2level_size50[7]->in[31] mux_2level_size50[7]->in[32] mux_2level_size50[7]->in[33] mux_2level_size50[7]->in[34] mux_2level_size50[7]->in[35] mux_2level_size50[7]->in[36] mux_2level_size50[7]->in[37] mux_2level_size50[7]->in[38] mux_2level_size50[7]->in[39] mux_2level_size50[7]->in[40] mux_2level_size50[7]->in[41] mux_2level_size50[7]->in[42] mux_2level_size50[7]->in[43] mux_2level_size50[7]->in[44] mux_2level_size50[7]->in[45] mux_2level_size50[7]->in[46] mux_2level_size50[7]->in[47] mux_2level_size50[7]->in[48] mux_2level_size50[7]->in[49] mux_2level_size50[7]->out sram[112]->outb sram[112]->out sram[113]->out sram[113]->outb sram[114]->out sram[114]->outb sram[115]->out sram[115]->outb sram[116]->out sram[116]->outb sram[117]->out sram[117]->outb sram[118]->out sram[118]->outb sram[119]->out sram[119]->outb sram[120]->outb sram[120]->out sram[121]->out sram[121]->outb sram[122]->out sram[122]->outb sram[123]->out sram[123]->outb sram[124]->out sram[124]->outb sram[125]->out sram[125]->outb sram[126]->out sram[126]->outb sram[127]->out sram[127]->outb gvdd_mux_2level_size50[7] 0 mux_2level_size50
***** SRAM bits for MUX[7], level=2, select_path_id=0. *****
*****1000000010000000*****
Xsram[112] sram->in sram[112]->out sram[112]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[112]->out) 0
.nodeset V(sram[112]->outb) vsp
Xsram[113] sram->in sram[113]->out sram[113]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[113]->out) 0
.nodeset V(sram[113]->outb) vsp
Xsram[114] sram->in sram[114]->out sram[114]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[114]->out) 0
.nodeset V(sram[114]->outb) vsp
Xsram[115] sram->in sram[115]->out sram[115]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[115]->out) 0
.nodeset V(sram[115]->outb) vsp
Xsram[116] sram->in sram[116]->out sram[116]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[116]->out) 0
.nodeset V(sram[116]->outb) vsp
Xsram[117] sram->in sram[117]->out sram[117]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[117]->out) 0
.nodeset V(sram[117]->outb) vsp
Xsram[118] sram->in sram[118]->out sram[118]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[118]->out) 0
.nodeset V(sram[118]->outb) vsp
Xsram[119] sram->in sram[119]->out sram[119]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[119]->out) 0
.nodeset V(sram[119]->outb) vsp
Xsram[120] sram->in sram[120]->out sram[120]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[120]->out) 0
.nodeset V(sram[120]->outb) vsp
Xsram[121] sram->in sram[121]->out sram[121]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[121]->out) 0
.nodeset V(sram[121]->outb) vsp
Xsram[122] sram->in sram[122]->out sram[122]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[122]->out) 0
.nodeset V(sram[122]->outb) vsp
Xsram[123] sram->in sram[123]->out sram[123]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[123]->out) 0
.nodeset V(sram[123]->outb) vsp
Xsram[124] sram->in sram[124]->out sram[124]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[124]->out) 0
.nodeset V(sram[124]->outb) vsp
Xsram[125] sram->in sram[125]->out sram[125]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[125]->out) 0
.nodeset V(sram[125]->outb) vsp
Xsram[126] sram->in sram[126]->out sram[126]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[126]->out) 0
.nodeset V(sram[126]->outb) vsp
Xsram[127] sram->in sram[127]->out sram[127]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[127]->out) 0
.nodeset V(sram[127]->outb) vsp
***** Signal mux_2level_size50[7]->in[0] density = 0, probability=0.*****
Vmux_2level_size50[7]->in[0] mux_2level_size50[7]->in[0] 0
+  0
***** Signal mux_2level_size50[7]->in[1] density = 0, probability=0.*****
Vmux_2level_size50[7]->in[1] mux_2level_size50[7]->in[1] 0
+  0
***** Signal mux_2level_size50[7]->in[2] density = 0, probability=0.*****
Vmux_2level_size50[7]->in[2] mux_2level_size50[7]->in[2] 0
+  0
***** Signal mux_2level_size50[7]->in[3] density = 0, probability=0.*****
Vmux_2level_size50[7]->in[3] mux_2level_size50[7]->in[3] 0
+  0
***** Signal mux_2level_size50[7]->in[4] density = 0, probability=0.*****
Vmux_2level_size50[7]->in[4] mux_2level_size50[7]->in[4] 0
+  0
***** Signal mux_2level_size50[7]->in[5] density = 0, probability=0.*****
Vmux_2level_size50[7]->in[5] mux_2level_size50[7]->in[5] 0
+  0
***** Signal mux_2level_size50[7]->in[6] density = 0, probability=0.*****
Vmux_2level_size50[7]->in[6] mux_2level_size50[7]->in[6] 0
+  0
***** Signal mux_2level_size50[7]->in[7] density = 0, probability=0.*****
Vmux_2level_size50[7]->in[7] mux_2level_size50[7]->in[7] 0
+  0
***** Signal mux_2level_size50[7]->in[8] density = 0, probability=0.*****
Vmux_2level_size50[7]->in[8] mux_2level_size50[7]->in[8] 0
+  0
***** Signal mux_2level_size50[7]->in[9] density = 0, probability=0.*****
Vmux_2level_size50[7]->in[9] mux_2level_size50[7]->in[9] 0
+  0
***** Signal mux_2level_size50[7]->in[10] density = 0, probability=0.*****
Vmux_2level_size50[7]->in[10] mux_2level_size50[7]->in[10] 0
+  0
***** Signal mux_2level_size50[7]->in[11] density = 0, probability=0.*****
Vmux_2level_size50[7]->in[11] mux_2level_size50[7]->in[11] 0
+  0
***** Signal mux_2level_size50[7]->in[12] density = 0, probability=0.*****
Vmux_2level_size50[7]->in[12] mux_2level_size50[7]->in[12] 0
+  0
***** Signal mux_2level_size50[7]->in[13] density = 0, probability=0.*****
Vmux_2level_size50[7]->in[13] mux_2level_size50[7]->in[13] 0
+  0
***** Signal mux_2level_size50[7]->in[14] density = 0, probability=0.*****
Vmux_2level_size50[7]->in[14] mux_2level_size50[7]->in[14] 0
+  0
***** Signal mux_2level_size50[7]->in[15] density = 0, probability=0.*****
Vmux_2level_size50[7]->in[15] mux_2level_size50[7]->in[15] 0
+  0
***** Signal mux_2level_size50[7]->in[16] density = 0, probability=0.*****
Vmux_2level_size50[7]->in[16] mux_2level_size50[7]->in[16] 0
+  0
***** Signal mux_2level_size50[7]->in[17] density = 0, probability=0.*****
Vmux_2level_size50[7]->in[17] mux_2level_size50[7]->in[17] 0
+  0
***** Signal mux_2level_size50[7]->in[18] density = 0, probability=0.*****
Vmux_2level_size50[7]->in[18] mux_2level_size50[7]->in[18] 0
+  0
***** Signal mux_2level_size50[7]->in[19] density = 0, probability=0.*****
Vmux_2level_size50[7]->in[19] mux_2level_size50[7]->in[19] 0
+  0
***** Signal mux_2level_size50[7]->in[20] density = 0, probability=0.*****
Vmux_2level_size50[7]->in[20] mux_2level_size50[7]->in[20] 0
+  0
***** Signal mux_2level_size50[7]->in[21] density = 0, probability=0.*****
Vmux_2level_size50[7]->in[21] mux_2level_size50[7]->in[21] 0
+  0
***** Signal mux_2level_size50[7]->in[22] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[7]->in[22] mux_2level_size50[7]->in[22] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[7]->in[23] density = 0, probability=0.*****
Vmux_2level_size50[7]->in[23] mux_2level_size50[7]->in[23] 0
+  0
***** Signal mux_2level_size50[7]->in[24] density = 0, probability=0.*****
Vmux_2level_size50[7]->in[24] mux_2level_size50[7]->in[24] 0
+  0
***** Signal mux_2level_size50[7]->in[25] density = 0, probability=0.*****
Vmux_2level_size50[7]->in[25] mux_2level_size50[7]->in[25] 0
+  0
***** Signal mux_2level_size50[7]->in[26] density = 0, probability=0.*****
Vmux_2level_size50[7]->in[26] mux_2level_size50[7]->in[26] 0
+  0
***** Signal mux_2level_size50[7]->in[27] density = 0, probability=0.*****
Vmux_2level_size50[7]->in[27] mux_2level_size50[7]->in[27] 0
+  0
***** Signal mux_2level_size50[7]->in[28] density = 0, probability=0.*****
Vmux_2level_size50[7]->in[28] mux_2level_size50[7]->in[28] 0
+  0
***** Signal mux_2level_size50[7]->in[29] density = 0, probability=0.*****
Vmux_2level_size50[7]->in[29] mux_2level_size50[7]->in[29] 0
+  0
***** Signal mux_2level_size50[7]->in[30] density = 0, probability=0.*****
Vmux_2level_size50[7]->in[30] mux_2level_size50[7]->in[30] 0
+  0
***** Signal mux_2level_size50[7]->in[31] density = 0, probability=0.*****
Vmux_2level_size50[7]->in[31] mux_2level_size50[7]->in[31] 0
+  0
***** Signal mux_2level_size50[7]->in[32] density = 0, probability=0.*****
Vmux_2level_size50[7]->in[32] mux_2level_size50[7]->in[32] 0
+  0
***** Signal mux_2level_size50[7]->in[33] density = 0, probability=0.*****
Vmux_2level_size50[7]->in[33] mux_2level_size50[7]->in[33] 0
+  0
***** Signal mux_2level_size50[7]->in[34] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[7]->in[34] mux_2level_size50[7]->in[34] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[7]->in[35] density = 0, probability=0.*****
Vmux_2level_size50[7]->in[35] mux_2level_size50[7]->in[35] 0
+  0
***** Signal mux_2level_size50[7]->in[36] density = 0, probability=0.*****
Vmux_2level_size50[7]->in[36] mux_2level_size50[7]->in[36] 0
+  0
***** Signal mux_2level_size50[7]->in[37] density = 0, probability=0.*****
Vmux_2level_size50[7]->in[37] mux_2level_size50[7]->in[37] 0
+  0
***** Signal mux_2level_size50[7]->in[38] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[7]->in[38] mux_2level_size50[7]->in[38] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[7]->in[39] density = 0, probability=0.*****
Vmux_2level_size50[7]->in[39] mux_2level_size50[7]->in[39] 0
+  0
***** Signal mux_2level_size50[7]->in[40] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[7]->in[40] mux_2level_size50[7]->in[40] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[7]->in[41] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[7]->in[41] mux_2level_size50[7]->in[41] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[7]->in[42] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[7]->in[42] mux_2level_size50[7]->in[42] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[7]->in[43] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[7]->in[43] mux_2level_size50[7]->in[43] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[7]->in[44] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[7]->in[44] mux_2level_size50[7]->in[44] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[7]->in[45] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[7]->in[45] mux_2level_size50[7]->in[45] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[7]->in[46] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[7]->in[46] mux_2level_size50[7]->in[46] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[7]->in[47] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[7]->in[47] mux_2level_size50[7]->in[47] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[7]->in[48] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[7]->in[48] mux_2level_size50[7]->in[48] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[7]->in[49] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[7]->in[49] mux_2level_size50[7]->in[49] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
Vgvdd_mux_2level_size50[7] gvdd_mux_2level_size50[7] 0 vsp
***** Measurements *****
***** Rise delay *****
.meas tran delay_rise_idle_mux50[7]_in[1]_crossbar trig v(mux_2level_size50[7]->in[0]) val='input_thres_pct_rise*vsp' rise=1 td='clock_period'
+          targ v(mux_2level_size50[7]->out) val='output_thres_pct_rise*vsp' rise=1 td='clock_period'
***** Fall delay *****
.meas tran delay_fall_idle_mux50[7]_in[1]_crossbar trig v(mux_2level_size50[7]->in[0]) val='input_thres_pct_fall*vsp' fall=1 td='clock_period'
+          targ v(mux_2level_size50[7]->out) val='output_thres_pct_fall*vsp' fall=1 td='clock_period'
***** Rise timing period *****
.meas start_rise_idle_mux50[7]_in[1]_crossbar when v(mux_2level_size50[7]->in[0])='slew_lower_thres_pct_rise*vsp' rise=1 td='clock_period'
.meas tran switch_rise_idle_mux50[7]_in[1]_crossbar trig v(mux_2level_size50[7]->in[0]) val='slew_lower_thres_pct_rise*vsp' rise=1 td='clock_period'
+          targ v(mux_2level_size50[7]->out) val='slew_upper_thres_pct_rise*vsp' rise=1 td='clock_period'
***** Fall timing period *****
.meas start_fall_idle_mux50[7]_in[1]_crossbar when v(mux_2level_size50[7]->in[0])='slew_lower_thres_pct_fall*vsp' fall=1 td='clock_period'
.meas tran switch_fall_idle_mux50[7]_in[1]_crossbar trig v(mux_2level_size50[7]->in[0]) val='slew_lower_thres_pct_fall*vsp' fall=1 td='clock_period'
+          targ v(mux_2level_size50[7]->out) val='slew_upper_thres_pct_fall*vsp' fall=1 td='clock_period'
***** Leakage Power Measurement *****
.meas tran mux_2level_size50[7]_leakage_power avg p(Vgvdd_mux_2level_size50[7]) from=0 to='clock_period'
.meas tran leakage_idle_mux50[7]_in[1]_crossbar param='mux_2level_size50[7]_leakage_power'
***** Dynamic Power Measurement *****
.meas tran mux_2level_size50[7]_dynamic_power avg p(Vgvdd_mux_2level_size50[7]) from='clock_period' to='6*clock_period'
.meas tran mux_2level_size50[7]_energy_per_cycle param='mux_2level_size50[7]_dynamic_power*clock_period'
.meas tran dynamic_power_idle_mux50[7]_in[1]_crossbar  param='mux_2level_size50[7]_dynamic_power'
.meas tran energy_per_cycle_idle_mux50[7]_in[1]_crossbar  param='dynamic_power_idle_mux50[7]_in[1]_crossbar*clock_period'
.meas tran dynamic_rise_idle_mux50[7]_in[1]_crossbar avg p(Vgvdd_mux_2level_size50[7]) from='start_rise_idle_mux50[7]_in[1]_crossbar' to='start_rise_idle_mux50[7]_in[1]_crossbar+switch_rise_idle_mux50[7]_in[1]_crossbar'
.meas tran dynamic_fall_idle_mux50[7]_in[1]_crossbar avg p(Vgvdd_mux_2level_size50[7]) from='start_fall_idle_mux50[7]_in[1]_crossbar' to='start_fall_idle_mux50[7]_in[1]_crossbar+switch_fall_idle_mux50[7]_in[1]_crossbar'
.meas tran sum_leakage_power_mux[0to7]
+          param='sum_leakage_power_mux[0to6]+leakage_idle_mux50[7]_in[1]_crossbar'
.meas tran sum_energy_per_cycle_mux[0to7]
+          param='sum_energy_per_cycle_mux[0to6]+energy_per_cycle_idle_mux50[7]_in[1]_crossbar'
Xload_inv[7]_no0 mux_2level_size50[7]->out mux_2level_size50[7]->out_out[0] gvdd_load 0 inv size=5
.meas tran sum_leakage_power_pb_mux[0to7]
+          param='sum_leakage_power_pb_mux[0to6]+leakage_idle_mux50[7]_in[1]_crossbar'
.meas tran sum_energy_per_cycle_pb_mux[0to7]
+          param='sum_energy_per_cycle_pb_mux[0to6]+energy_per_cycle_idle_mux50[7]_in[1]_crossbar'
Xmux_2level_size50[8] mux_2level_size50[8]->in[0] mux_2level_size50[8]->in[1] mux_2level_size50[8]->in[2] mux_2level_size50[8]->in[3] mux_2level_size50[8]->in[4] mux_2level_size50[8]->in[5] mux_2level_size50[8]->in[6] mux_2level_size50[8]->in[7] mux_2level_size50[8]->in[8] mux_2level_size50[8]->in[9] mux_2level_size50[8]->in[10] mux_2level_size50[8]->in[11] mux_2level_size50[8]->in[12] mux_2level_size50[8]->in[13] mux_2level_size50[8]->in[14] mux_2level_size50[8]->in[15] mux_2level_size50[8]->in[16] mux_2level_size50[8]->in[17] mux_2level_size50[8]->in[18] mux_2level_size50[8]->in[19] mux_2level_size50[8]->in[20] mux_2level_size50[8]->in[21] mux_2level_size50[8]->in[22] mux_2level_size50[8]->in[23] mux_2level_size50[8]->in[24] mux_2level_size50[8]->in[25] mux_2level_size50[8]->in[26] mux_2level_size50[8]->in[27] mux_2level_size50[8]->in[28] mux_2level_size50[8]->in[29] mux_2level_size50[8]->in[30] mux_2level_size50[8]->in[31] mux_2level_size50[8]->in[32] mux_2level_size50[8]->in[33] mux_2level_size50[8]->in[34] mux_2level_size50[8]->in[35] mux_2level_size50[8]->in[36] mux_2level_size50[8]->in[37] mux_2level_size50[8]->in[38] mux_2level_size50[8]->in[39] mux_2level_size50[8]->in[40] mux_2level_size50[8]->in[41] mux_2level_size50[8]->in[42] mux_2level_size50[8]->in[43] mux_2level_size50[8]->in[44] mux_2level_size50[8]->in[45] mux_2level_size50[8]->in[46] mux_2level_size50[8]->in[47] mux_2level_size50[8]->in[48] mux_2level_size50[8]->in[49] mux_2level_size50[8]->out sram[128]->outb sram[128]->out sram[129]->out sram[129]->outb sram[130]->out sram[130]->outb sram[131]->out sram[131]->outb sram[132]->out sram[132]->outb sram[133]->out sram[133]->outb sram[134]->out sram[134]->outb sram[135]->out sram[135]->outb sram[136]->outb sram[136]->out sram[137]->out sram[137]->outb sram[138]->out sram[138]->outb sram[139]->out sram[139]->outb sram[140]->out sram[140]->outb sram[141]->out sram[141]->outb sram[142]->out sram[142]->outb sram[143]->out sram[143]->outb gvdd_mux_2level_size50[8] 0 mux_2level_size50
***** SRAM bits for MUX[8], level=2, select_path_id=0. *****
*****1000000010000000*****
Xsram[128] sram->in sram[128]->out sram[128]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[128]->out) 0
.nodeset V(sram[128]->outb) vsp
Xsram[129] sram->in sram[129]->out sram[129]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[129]->out) 0
.nodeset V(sram[129]->outb) vsp
Xsram[130] sram->in sram[130]->out sram[130]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[130]->out) 0
.nodeset V(sram[130]->outb) vsp
Xsram[131] sram->in sram[131]->out sram[131]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[131]->out) 0
.nodeset V(sram[131]->outb) vsp
Xsram[132] sram->in sram[132]->out sram[132]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[132]->out) 0
.nodeset V(sram[132]->outb) vsp
Xsram[133] sram->in sram[133]->out sram[133]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[133]->out) 0
.nodeset V(sram[133]->outb) vsp
Xsram[134] sram->in sram[134]->out sram[134]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[134]->out) 0
.nodeset V(sram[134]->outb) vsp
Xsram[135] sram->in sram[135]->out sram[135]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[135]->out) 0
.nodeset V(sram[135]->outb) vsp
Xsram[136] sram->in sram[136]->out sram[136]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[136]->out) 0
.nodeset V(sram[136]->outb) vsp
Xsram[137] sram->in sram[137]->out sram[137]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[137]->out) 0
.nodeset V(sram[137]->outb) vsp
Xsram[138] sram->in sram[138]->out sram[138]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[138]->out) 0
.nodeset V(sram[138]->outb) vsp
Xsram[139] sram->in sram[139]->out sram[139]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[139]->out) 0
.nodeset V(sram[139]->outb) vsp
Xsram[140] sram->in sram[140]->out sram[140]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[140]->out) 0
.nodeset V(sram[140]->outb) vsp
Xsram[141] sram->in sram[141]->out sram[141]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[141]->out) 0
.nodeset V(sram[141]->outb) vsp
Xsram[142] sram->in sram[142]->out sram[142]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[142]->out) 0
.nodeset V(sram[142]->outb) vsp
Xsram[143] sram->in sram[143]->out sram[143]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[143]->out) 0
.nodeset V(sram[143]->outb) vsp
***** Signal mux_2level_size50[8]->in[0] density = 0, probability=0.*****
Vmux_2level_size50[8]->in[0] mux_2level_size50[8]->in[0] 0
+  0
***** Signal mux_2level_size50[8]->in[1] density = 0, probability=0.*****
Vmux_2level_size50[8]->in[1] mux_2level_size50[8]->in[1] 0
+  0
***** Signal mux_2level_size50[8]->in[2] density = 0, probability=0.*****
Vmux_2level_size50[8]->in[2] mux_2level_size50[8]->in[2] 0
+  0
***** Signal mux_2level_size50[8]->in[3] density = 0, probability=0.*****
Vmux_2level_size50[8]->in[3] mux_2level_size50[8]->in[3] 0
+  0
***** Signal mux_2level_size50[8]->in[4] density = 0, probability=0.*****
Vmux_2level_size50[8]->in[4] mux_2level_size50[8]->in[4] 0
+  0
***** Signal mux_2level_size50[8]->in[5] density = 0, probability=0.*****
Vmux_2level_size50[8]->in[5] mux_2level_size50[8]->in[5] 0
+  0
***** Signal mux_2level_size50[8]->in[6] density = 0, probability=0.*****
Vmux_2level_size50[8]->in[6] mux_2level_size50[8]->in[6] 0
+  0
***** Signal mux_2level_size50[8]->in[7] density = 0, probability=0.*****
Vmux_2level_size50[8]->in[7] mux_2level_size50[8]->in[7] 0
+  0
***** Signal mux_2level_size50[8]->in[8] density = 0, probability=0.*****
Vmux_2level_size50[8]->in[8] mux_2level_size50[8]->in[8] 0
+  0
***** Signal mux_2level_size50[8]->in[9] density = 0, probability=0.*****
Vmux_2level_size50[8]->in[9] mux_2level_size50[8]->in[9] 0
+  0
***** Signal mux_2level_size50[8]->in[10] density = 0, probability=0.*****
Vmux_2level_size50[8]->in[10] mux_2level_size50[8]->in[10] 0
+  0
***** Signal mux_2level_size50[8]->in[11] density = 0, probability=0.*****
Vmux_2level_size50[8]->in[11] mux_2level_size50[8]->in[11] 0
+  0
***** Signal mux_2level_size50[8]->in[12] density = 0, probability=0.*****
Vmux_2level_size50[8]->in[12] mux_2level_size50[8]->in[12] 0
+  0
***** Signal mux_2level_size50[8]->in[13] density = 0, probability=0.*****
Vmux_2level_size50[8]->in[13] mux_2level_size50[8]->in[13] 0
+  0
***** Signal mux_2level_size50[8]->in[14] density = 0, probability=0.*****
Vmux_2level_size50[8]->in[14] mux_2level_size50[8]->in[14] 0
+  0
***** Signal mux_2level_size50[8]->in[15] density = 0, probability=0.*****
Vmux_2level_size50[8]->in[15] mux_2level_size50[8]->in[15] 0
+  0
***** Signal mux_2level_size50[8]->in[16] density = 0, probability=0.*****
Vmux_2level_size50[8]->in[16] mux_2level_size50[8]->in[16] 0
+  0
***** Signal mux_2level_size50[8]->in[17] density = 0, probability=0.*****
Vmux_2level_size50[8]->in[17] mux_2level_size50[8]->in[17] 0
+  0
***** Signal mux_2level_size50[8]->in[18] density = 0, probability=0.*****
Vmux_2level_size50[8]->in[18] mux_2level_size50[8]->in[18] 0
+  0
***** Signal mux_2level_size50[8]->in[19] density = 0, probability=0.*****
Vmux_2level_size50[8]->in[19] mux_2level_size50[8]->in[19] 0
+  0
***** Signal mux_2level_size50[8]->in[20] density = 0, probability=0.*****
Vmux_2level_size50[8]->in[20] mux_2level_size50[8]->in[20] 0
+  0
***** Signal mux_2level_size50[8]->in[21] density = 0, probability=0.*****
Vmux_2level_size50[8]->in[21] mux_2level_size50[8]->in[21] 0
+  0
***** Signal mux_2level_size50[8]->in[22] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[8]->in[22] mux_2level_size50[8]->in[22] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[8]->in[23] density = 0, probability=0.*****
Vmux_2level_size50[8]->in[23] mux_2level_size50[8]->in[23] 0
+  0
***** Signal mux_2level_size50[8]->in[24] density = 0, probability=0.*****
Vmux_2level_size50[8]->in[24] mux_2level_size50[8]->in[24] 0
+  0
***** Signal mux_2level_size50[8]->in[25] density = 0, probability=0.*****
Vmux_2level_size50[8]->in[25] mux_2level_size50[8]->in[25] 0
+  0
***** Signal mux_2level_size50[8]->in[26] density = 0, probability=0.*****
Vmux_2level_size50[8]->in[26] mux_2level_size50[8]->in[26] 0
+  0
***** Signal mux_2level_size50[8]->in[27] density = 0, probability=0.*****
Vmux_2level_size50[8]->in[27] mux_2level_size50[8]->in[27] 0
+  0
***** Signal mux_2level_size50[8]->in[28] density = 0, probability=0.*****
Vmux_2level_size50[8]->in[28] mux_2level_size50[8]->in[28] 0
+  0
***** Signal mux_2level_size50[8]->in[29] density = 0, probability=0.*****
Vmux_2level_size50[8]->in[29] mux_2level_size50[8]->in[29] 0
+  0
***** Signal mux_2level_size50[8]->in[30] density = 0, probability=0.*****
Vmux_2level_size50[8]->in[30] mux_2level_size50[8]->in[30] 0
+  0
***** Signal mux_2level_size50[8]->in[31] density = 0, probability=0.*****
Vmux_2level_size50[8]->in[31] mux_2level_size50[8]->in[31] 0
+  0
***** Signal mux_2level_size50[8]->in[32] density = 0, probability=0.*****
Vmux_2level_size50[8]->in[32] mux_2level_size50[8]->in[32] 0
+  0
***** Signal mux_2level_size50[8]->in[33] density = 0, probability=0.*****
Vmux_2level_size50[8]->in[33] mux_2level_size50[8]->in[33] 0
+  0
***** Signal mux_2level_size50[8]->in[34] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[8]->in[34] mux_2level_size50[8]->in[34] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[8]->in[35] density = 0, probability=0.*****
Vmux_2level_size50[8]->in[35] mux_2level_size50[8]->in[35] 0
+  0
***** Signal mux_2level_size50[8]->in[36] density = 0, probability=0.*****
Vmux_2level_size50[8]->in[36] mux_2level_size50[8]->in[36] 0
+  0
***** Signal mux_2level_size50[8]->in[37] density = 0, probability=0.*****
Vmux_2level_size50[8]->in[37] mux_2level_size50[8]->in[37] 0
+  0
***** Signal mux_2level_size50[8]->in[38] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[8]->in[38] mux_2level_size50[8]->in[38] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[8]->in[39] density = 0, probability=0.*****
Vmux_2level_size50[8]->in[39] mux_2level_size50[8]->in[39] 0
+  0
***** Signal mux_2level_size50[8]->in[40] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[8]->in[40] mux_2level_size50[8]->in[40] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[8]->in[41] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[8]->in[41] mux_2level_size50[8]->in[41] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[8]->in[42] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[8]->in[42] mux_2level_size50[8]->in[42] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[8]->in[43] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[8]->in[43] mux_2level_size50[8]->in[43] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[8]->in[44] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[8]->in[44] mux_2level_size50[8]->in[44] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[8]->in[45] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[8]->in[45] mux_2level_size50[8]->in[45] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[8]->in[46] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[8]->in[46] mux_2level_size50[8]->in[46] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[8]->in[47] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[8]->in[47] mux_2level_size50[8]->in[47] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[8]->in[48] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[8]->in[48] mux_2level_size50[8]->in[48] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[8]->in[49] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[8]->in[49] mux_2level_size50[8]->in[49] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
Vgvdd_mux_2level_size50[8] gvdd_mux_2level_size50[8] 0 vsp
***** Measurements *****
***** Rise delay *****
.meas tran delay_rise_idle_mux50[8]_in[2]_crossbar trig v(mux_2level_size50[8]->in[0]) val='input_thres_pct_rise*vsp' rise=1 td='clock_period'
+          targ v(mux_2level_size50[8]->out) val='output_thres_pct_rise*vsp' rise=1 td='clock_period'
***** Fall delay *****
.meas tran delay_fall_idle_mux50[8]_in[2]_crossbar trig v(mux_2level_size50[8]->in[0]) val='input_thres_pct_fall*vsp' fall=1 td='clock_period'
+          targ v(mux_2level_size50[8]->out) val='output_thres_pct_fall*vsp' fall=1 td='clock_period'
***** Rise timing period *****
.meas start_rise_idle_mux50[8]_in[2]_crossbar when v(mux_2level_size50[8]->in[0])='slew_lower_thres_pct_rise*vsp' rise=1 td='clock_period'
.meas tran switch_rise_idle_mux50[8]_in[2]_crossbar trig v(mux_2level_size50[8]->in[0]) val='slew_lower_thres_pct_rise*vsp' rise=1 td='clock_period'
+          targ v(mux_2level_size50[8]->out) val='slew_upper_thres_pct_rise*vsp' rise=1 td='clock_period'
***** Fall timing period *****
.meas start_fall_idle_mux50[8]_in[2]_crossbar when v(mux_2level_size50[8]->in[0])='slew_lower_thres_pct_fall*vsp' fall=1 td='clock_period'
.meas tran switch_fall_idle_mux50[8]_in[2]_crossbar trig v(mux_2level_size50[8]->in[0]) val='slew_lower_thres_pct_fall*vsp' fall=1 td='clock_period'
+          targ v(mux_2level_size50[8]->out) val='slew_upper_thres_pct_fall*vsp' fall=1 td='clock_period'
***** Leakage Power Measurement *****
.meas tran mux_2level_size50[8]_leakage_power avg p(Vgvdd_mux_2level_size50[8]) from=0 to='clock_period'
.meas tran leakage_idle_mux50[8]_in[2]_crossbar param='mux_2level_size50[8]_leakage_power'
***** Dynamic Power Measurement *****
.meas tran mux_2level_size50[8]_dynamic_power avg p(Vgvdd_mux_2level_size50[8]) from='clock_period' to='6*clock_period'
.meas tran mux_2level_size50[8]_energy_per_cycle param='mux_2level_size50[8]_dynamic_power*clock_period'
.meas tran dynamic_power_idle_mux50[8]_in[2]_crossbar  param='mux_2level_size50[8]_dynamic_power'
.meas tran energy_per_cycle_idle_mux50[8]_in[2]_crossbar  param='dynamic_power_idle_mux50[8]_in[2]_crossbar*clock_period'
.meas tran dynamic_rise_idle_mux50[8]_in[2]_crossbar avg p(Vgvdd_mux_2level_size50[8]) from='start_rise_idle_mux50[8]_in[2]_crossbar' to='start_rise_idle_mux50[8]_in[2]_crossbar+switch_rise_idle_mux50[8]_in[2]_crossbar'
.meas tran dynamic_fall_idle_mux50[8]_in[2]_crossbar avg p(Vgvdd_mux_2level_size50[8]) from='start_fall_idle_mux50[8]_in[2]_crossbar' to='start_fall_idle_mux50[8]_in[2]_crossbar+switch_fall_idle_mux50[8]_in[2]_crossbar'
.meas tran sum_leakage_power_mux[0to8]
+          param='sum_leakage_power_mux[0to7]+leakage_idle_mux50[8]_in[2]_crossbar'
.meas tran sum_energy_per_cycle_mux[0to8]
+          param='sum_energy_per_cycle_mux[0to7]+energy_per_cycle_idle_mux50[8]_in[2]_crossbar'
Xload_inv[8]_no0 mux_2level_size50[8]->out mux_2level_size50[8]->out_out[0] gvdd_load 0 inv size=5
.meas tran sum_leakage_power_pb_mux[0to8]
+          param='sum_leakage_power_pb_mux[0to7]+leakage_idle_mux50[8]_in[2]_crossbar'
.meas tran sum_energy_per_cycle_pb_mux[0to8]
+          param='sum_energy_per_cycle_pb_mux[0to7]+energy_per_cycle_idle_mux50[8]_in[2]_crossbar'
Xmux_2level_size50[9] mux_2level_size50[9]->in[0] mux_2level_size50[9]->in[1] mux_2level_size50[9]->in[2] mux_2level_size50[9]->in[3] mux_2level_size50[9]->in[4] mux_2level_size50[9]->in[5] mux_2level_size50[9]->in[6] mux_2level_size50[9]->in[7] mux_2level_size50[9]->in[8] mux_2level_size50[9]->in[9] mux_2level_size50[9]->in[10] mux_2level_size50[9]->in[11] mux_2level_size50[9]->in[12] mux_2level_size50[9]->in[13] mux_2level_size50[9]->in[14] mux_2level_size50[9]->in[15] mux_2level_size50[9]->in[16] mux_2level_size50[9]->in[17] mux_2level_size50[9]->in[18] mux_2level_size50[9]->in[19] mux_2level_size50[9]->in[20] mux_2level_size50[9]->in[21] mux_2level_size50[9]->in[22] mux_2level_size50[9]->in[23] mux_2level_size50[9]->in[24] mux_2level_size50[9]->in[25] mux_2level_size50[9]->in[26] mux_2level_size50[9]->in[27] mux_2level_size50[9]->in[28] mux_2level_size50[9]->in[29] mux_2level_size50[9]->in[30] mux_2level_size50[9]->in[31] mux_2level_size50[9]->in[32] mux_2level_size50[9]->in[33] mux_2level_size50[9]->in[34] mux_2level_size50[9]->in[35] mux_2level_size50[9]->in[36] mux_2level_size50[9]->in[37] mux_2level_size50[9]->in[38] mux_2level_size50[9]->in[39] mux_2level_size50[9]->in[40] mux_2level_size50[9]->in[41] mux_2level_size50[9]->in[42] mux_2level_size50[9]->in[43] mux_2level_size50[9]->in[44] mux_2level_size50[9]->in[45] mux_2level_size50[9]->in[46] mux_2level_size50[9]->in[47] mux_2level_size50[9]->in[48] mux_2level_size50[9]->in[49] mux_2level_size50[9]->out sram[144]->outb sram[144]->out sram[145]->out sram[145]->outb sram[146]->out sram[146]->outb sram[147]->out sram[147]->outb sram[148]->out sram[148]->outb sram[149]->out sram[149]->outb sram[150]->out sram[150]->outb sram[151]->out sram[151]->outb sram[152]->outb sram[152]->out sram[153]->out sram[153]->outb sram[154]->out sram[154]->outb sram[155]->out sram[155]->outb sram[156]->out sram[156]->outb sram[157]->out sram[157]->outb sram[158]->out sram[158]->outb sram[159]->out sram[159]->outb gvdd_mux_2level_size50[9] 0 mux_2level_size50
***** SRAM bits for MUX[9], level=2, select_path_id=0. *****
*****1000000010000000*****
Xsram[144] sram->in sram[144]->out sram[144]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[144]->out) 0
.nodeset V(sram[144]->outb) vsp
Xsram[145] sram->in sram[145]->out sram[145]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[145]->out) 0
.nodeset V(sram[145]->outb) vsp
Xsram[146] sram->in sram[146]->out sram[146]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[146]->out) 0
.nodeset V(sram[146]->outb) vsp
Xsram[147] sram->in sram[147]->out sram[147]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[147]->out) 0
.nodeset V(sram[147]->outb) vsp
Xsram[148] sram->in sram[148]->out sram[148]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[148]->out) 0
.nodeset V(sram[148]->outb) vsp
Xsram[149] sram->in sram[149]->out sram[149]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[149]->out) 0
.nodeset V(sram[149]->outb) vsp
Xsram[150] sram->in sram[150]->out sram[150]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[150]->out) 0
.nodeset V(sram[150]->outb) vsp
Xsram[151] sram->in sram[151]->out sram[151]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[151]->out) 0
.nodeset V(sram[151]->outb) vsp
Xsram[152] sram->in sram[152]->out sram[152]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[152]->out) 0
.nodeset V(sram[152]->outb) vsp
Xsram[153] sram->in sram[153]->out sram[153]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[153]->out) 0
.nodeset V(sram[153]->outb) vsp
Xsram[154] sram->in sram[154]->out sram[154]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[154]->out) 0
.nodeset V(sram[154]->outb) vsp
Xsram[155] sram->in sram[155]->out sram[155]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[155]->out) 0
.nodeset V(sram[155]->outb) vsp
Xsram[156] sram->in sram[156]->out sram[156]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[156]->out) 0
.nodeset V(sram[156]->outb) vsp
Xsram[157] sram->in sram[157]->out sram[157]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[157]->out) 0
.nodeset V(sram[157]->outb) vsp
Xsram[158] sram->in sram[158]->out sram[158]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[158]->out) 0
.nodeset V(sram[158]->outb) vsp
Xsram[159] sram->in sram[159]->out sram[159]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[159]->out) 0
.nodeset V(sram[159]->outb) vsp
***** Signal mux_2level_size50[9]->in[0] density = 0, probability=0.*****
Vmux_2level_size50[9]->in[0] mux_2level_size50[9]->in[0] 0
+  0
***** Signal mux_2level_size50[9]->in[1] density = 0, probability=0.*****
Vmux_2level_size50[9]->in[1] mux_2level_size50[9]->in[1] 0
+  0
***** Signal mux_2level_size50[9]->in[2] density = 0, probability=0.*****
Vmux_2level_size50[9]->in[2] mux_2level_size50[9]->in[2] 0
+  0
***** Signal mux_2level_size50[9]->in[3] density = 0, probability=0.*****
Vmux_2level_size50[9]->in[3] mux_2level_size50[9]->in[3] 0
+  0
***** Signal mux_2level_size50[9]->in[4] density = 0, probability=0.*****
Vmux_2level_size50[9]->in[4] mux_2level_size50[9]->in[4] 0
+  0
***** Signal mux_2level_size50[9]->in[5] density = 0, probability=0.*****
Vmux_2level_size50[9]->in[5] mux_2level_size50[9]->in[5] 0
+  0
***** Signal mux_2level_size50[9]->in[6] density = 0, probability=0.*****
Vmux_2level_size50[9]->in[6] mux_2level_size50[9]->in[6] 0
+  0
***** Signal mux_2level_size50[9]->in[7] density = 0, probability=0.*****
Vmux_2level_size50[9]->in[7] mux_2level_size50[9]->in[7] 0
+  0
***** Signal mux_2level_size50[9]->in[8] density = 0, probability=0.*****
Vmux_2level_size50[9]->in[8] mux_2level_size50[9]->in[8] 0
+  0
***** Signal mux_2level_size50[9]->in[9] density = 0, probability=0.*****
Vmux_2level_size50[9]->in[9] mux_2level_size50[9]->in[9] 0
+  0
***** Signal mux_2level_size50[9]->in[10] density = 0, probability=0.*****
Vmux_2level_size50[9]->in[10] mux_2level_size50[9]->in[10] 0
+  0
***** Signal mux_2level_size50[9]->in[11] density = 0, probability=0.*****
Vmux_2level_size50[9]->in[11] mux_2level_size50[9]->in[11] 0
+  0
***** Signal mux_2level_size50[9]->in[12] density = 0, probability=0.*****
Vmux_2level_size50[9]->in[12] mux_2level_size50[9]->in[12] 0
+  0
***** Signal mux_2level_size50[9]->in[13] density = 0, probability=0.*****
Vmux_2level_size50[9]->in[13] mux_2level_size50[9]->in[13] 0
+  0
***** Signal mux_2level_size50[9]->in[14] density = 0, probability=0.*****
Vmux_2level_size50[9]->in[14] mux_2level_size50[9]->in[14] 0
+  0
***** Signal mux_2level_size50[9]->in[15] density = 0, probability=0.*****
Vmux_2level_size50[9]->in[15] mux_2level_size50[9]->in[15] 0
+  0
***** Signal mux_2level_size50[9]->in[16] density = 0, probability=0.*****
Vmux_2level_size50[9]->in[16] mux_2level_size50[9]->in[16] 0
+  0
***** Signal mux_2level_size50[9]->in[17] density = 0, probability=0.*****
Vmux_2level_size50[9]->in[17] mux_2level_size50[9]->in[17] 0
+  0
***** Signal mux_2level_size50[9]->in[18] density = 0, probability=0.*****
Vmux_2level_size50[9]->in[18] mux_2level_size50[9]->in[18] 0
+  0
***** Signal mux_2level_size50[9]->in[19] density = 0, probability=0.*****
Vmux_2level_size50[9]->in[19] mux_2level_size50[9]->in[19] 0
+  0
***** Signal mux_2level_size50[9]->in[20] density = 0, probability=0.*****
Vmux_2level_size50[9]->in[20] mux_2level_size50[9]->in[20] 0
+  0
***** Signal mux_2level_size50[9]->in[21] density = 0, probability=0.*****
Vmux_2level_size50[9]->in[21] mux_2level_size50[9]->in[21] 0
+  0
***** Signal mux_2level_size50[9]->in[22] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[9]->in[22] mux_2level_size50[9]->in[22] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[9]->in[23] density = 0, probability=0.*****
Vmux_2level_size50[9]->in[23] mux_2level_size50[9]->in[23] 0
+  0
***** Signal mux_2level_size50[9]->in[24] density = 0, probability=0.*****
Vmux_2level_size50[9]->in[24] mux_2level_size50[9]->in[24] 0
+  0
***** Signal mux_2level_size50[9]->in[25] density = 0, probability=0.*****
Vmux_2level_size50[9]->in[25] mux_2level_size50[9]->in[25] 0
+  0
***** Signal mux_2level_size50[9]->in[26] density = 0, probability=0.*****
Vmux_2level_size50[9]->in[26] mux_2level_size50[9]->in[26] 0
+  0
***** Signal mux_2level_size50[9]->in[27] density = 0, probability=0.*****
Vmux_2level_size50[9]->in[27] mux_2level_size50[9]->in[27] 0
+  0
***** Signal mux_2level_size50[9]->in[28] density = 0, probability=0.*****
Vmux_2level_size50[9]->in[28] mux_2level_size50[9]->in[28] 0
+  0
***** Signal mux_2level_size50[9]->in[29] density = 0, probability=0.*****
Vmux_2level_size50[9]->in[29] mux_2level_size50[9]->in[29] 0
+  0
***** Signal mux_2level_size50[9]->in[30] density = 0, probability=0.*****
Vmux_2level_size50[9]->in[30] mux_2level_size50[9]->in[30] 0
+  0
***** Signal mux_2level_size50[9]->in[31] density = 0, probability=0.*****
Vmux_2level_size50[9]->in[31] mux_2level_size50[9]->in[31] 0
+  0
***** Signal mux_2level_size50[9]->in[32] density = 0, probability=0.*****
Vmux_2level_size50[9]->in[32] mux_2level_size50[9]->in[32] 0
+  0
***** Signal mux_2level_size50[9]->in[33] density = 0, probability=0.*****
Vmux_2level_size50[9]->in[33] mux_2level_size50[9]->in[33] 0
+  0
***** Signal mux_2level_size50[9]->in[34] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[9]->in[34] mux_2level_size50[9]->in[34] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[9]->in[35] density = 0, probability=0.*****
Vmux_2level_size50[9]->in[35] mux_2level_size50[9]->in[35] 0
+  0
***** Signal mux_2level_size50[9]->in[36] density = 0, probability=0.*****
Vmux_2level_size50[9]->in[36] mux_2level_size50[9]->in[36] 0
+  0
***** Signal mux_2level_size50[9]->in[37] density = 0, probability=0.*****
Vmux_2level_size50[9]->in[37] mux_2level_size50[9]->in[37] 0
+  0
***** Signal mux_2level_size50[9]->in[38] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[9]->in[38] mux_2level_size50[9]->in[38] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[9]->in[39] density = 0, probability=0.*****
Vmux_2level_size50[9]->in[39] mux_2level_size50[9]->in[39] 0
+  0
***** Signal mux_2level_size50[9]->in[40] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[9]->in[40] mux_2level_size50[9]->in[40] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[9]->in[41] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[9]->in[41] mux_2level_size50[9]->in[41] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[9]->in[42] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[9]->in[42] mux_2level_size50[9]->in[42] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[9]->in[43] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[9]->in[43] mux_2level_size50[9]->in[43] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[9]->in[44] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[9]->in[44] mux_2level_size50[9]->in[44] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[9]->in[45] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[9]->in[45] mux_2level_size50[9]->in[45] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[9]->in[46] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[9]->in[46] mux_2level_size50[9]->in[46] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[9]->in[47] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[9]->in[47] mux_2level_size50[9]->in[47] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[9]->in[48] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[9]->in[48] mux_2level_size50[9]->in[48] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[9]->in[49] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[9]->in[49] mux_2level_size50[9]->in[49] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
Vgvdd_mux_2level_size50[9] gvdd_mux_2level_size50[9] 0 vsp
***** Measurements *****
***** Rise delay *****
.meas tran delay_rise_idle_mux50[9]_in[3]_crossbar trig v(mux_2level_size50[9]->in[0]) val='input_thres_pct_rise*vsp' rise=1 td='clock_period'
+          targ v(mux_2level_size50[9]->out) val='output_thres_pct_rise*vsp' rise=1 td='clock_period'
***** Fall delay *****
.meas tran delay_fall_idle_mux50[9]_in[3]_crossbar trig v(mux_2level_size50[9]->in[0]) val='input_thres_pct_fall*vsp' fall=1 td='clock_period'
+          targ v(mux_2level_size50[9]->out) val='output_thres_pct_fall*vsp' fall=1 td='clock_period'
***** Rise timing period *****
.meas start_rise_idle_mux50[9]_in[3]_crossbar when v(mux_2level_size50[9]->in[0])='slew_lower_thres_pct_rise*vsp' rise=1 td='clock_period'
.meas tran switch_rise_idle_mux50[9]_in[3]_crossbar trig v(mux_2level_size50[9]->in[0]) val='slew_lower_thres_pct_rise*vsp' rise=1 td='clock_period'
+          targ v(mux_2level_size50[9]->out) val='slew_upper_thres_pct_rise*vsp' rise=1 td='clock_period'
***** Fall timing period *****
.meas start_fall_idle_mux50[9]_in[3]_crossbar when v(mux_2level_size50[9]->in[0])='slew_lower_thres_pct_fall*vsp' fall=1 td='clock_period'
.meas tran switch_fall_idle_mux50[9]_in[3]_crossbar trig v(mux_2level_size50[9]->in[0]) val='slew_lower_thres_pct_fall*vsp' fall=1 td='clock_period'
+          targ v(mux_2level_size50[9]->out) val='slew_upper_thres_pct_fall*vsp' fall=1 td='clock_period'
***** Leakage Power Measurement *****
.meas tran mux_2level_size50[9]_leakage_power avg p(Vgvdd_mux_2level_size50[9]) from=0 to='clock_period'
.meas tran leakage_idle_mux50[9]_in[3]_crossbar param='mux_2level_size50[9]_leakage_power'
***** Dynamic Power Measurement *****
.meas tran mux_2level_size50[9]_dynamic_power avg p(Vgvdd_mux_2level_size50[9]) from='clock_period' to='6*clock_period'
.meas tran mux_2level_size50[9]_energy_per_cycle param='mux_2level_size50[9]_dynamic_power*clock_period'
.meas tran dynamic_power_idle_mux50[9]_in[3]_crossbar  param='mux_2level_size50[9]_dynamic_power'
.meas tran energy_per_cycle_idle_mux50[9]_in[3]_crossbar  param='dynamic_power_idle_mux50[9]_in[3]_crossbar*clock_period'
.meas tran dynamic_rise_idle_mux50[9]_in[3]_crossbar avg p(Vgvdd_mux_2level_size50[9]) from='start_rise_idle_mux50[9]_in[3]_crossbar' to='start_rise_idle_mux50[9]_in[3]_crossbar+switch_rise_idle_mux50[9]_in[3]_crossbar'
.meas tran dynamic_fall_idle_mux50[9]_in[3]_crossbar avg p(Vgvdd_mux_2level_size50[9]) from='start_fall_idle_mux50[9]_in[3]_crossbar' to='start_fall_idle_mux50[9]_in[3]_crossbar+switch_fall_idle_mux50[9]_in[3]_crossbar'
.meas tran sum_leakage_power_mux[0to9]
+          param='sum_leakage_power_mux[0to8]+leakage_idle_mux50[9]_in[3]_crossbar'
.meas tran sum_energy_per_cycle_mux[0to9]
+          param='sum_energy_per_cycle_mux[0to8]+energy_per_cycle_idle_mux50[9]_in[3]_crossbar'
Xload_inv[9]_no0 mux_2level_size50[9]->out mux_2level_size50[9]->out_out[0] gvdd_load 0 inv size=5
.meas tran sum_leakage_power_pb_mux[0to9]
+          param='sum_leakage_power_pb_mux[0to8]+leakage_idle_mux50[9]_in[3]_crossbar'
.meas tran sum_energy_per_cycle_pb_mux[0to9]
+          param='sum_energy_per_cycle_pb_mux[0to8]+energy_per_cycle_idle_mux50[9]_in[3]_crossbar'
Xmux_2level_size50[10] mux_2level_size50[10]->in[0] mux_2level_size50[10]->in[1] mux_2level_size50[10]->in[2] mux_2level_size50[10]->in[3] mux_2level_size50[10]->in[4] mux_2level_size50[10]->in[5] mux_2level_size50[10]->in[6] mux_2level_size50[10]->in[7] mux_2level_size50[10]->in[8] mux_2level_size50[10]->in[9] mux_2level_size50[10]->in[10] mux_2level_size50[10]->in[11] mux_2level_size50[10]->in[12] mux_2level_size50[10]->in[13] mux_2level_size50[10]->in[14] mux_2level_size50[10]->in[15] mux_2level_size50[10]->in[16] mux_2level_size50[10]->in[17] mux_2level_size50[10]->in[18] mux_2level_size50[10]->in[19] mux_2level_size50[10]->in[20] mux_2level_size50[10]->in[21] mux_2level_size50[10]->in[22] mux_2level_size50[10]->in[23] mux_2level_size50[10]->in[24] mux_2level_size50[10]->in[25] mux_2level_size50[10]->in[26] mux_2level_size50[10]->in[27] mux_2level_size50[10]->in[28] mux_2level_size50[10]->in[29] mux_2level_size50[10]->in[30] mux_2level_size50[10]->in[31] mux_2level_size50[10]->in[32] mux_2level_size50[10]->in[33] mux_2level_size50[10]->in[34] mux_2level_size50[10]->in[35] mux_2level_size50[10]->in[36] mux_2level_size50[10]->in[37] mux_2level_size50[10]->in[38] mux_2level_size50[10]->in[39] mux_2level_size50[10]->in[40] mux_2level_size50[10]->in[41] mux_2level_size50[10]->in[42] mux_2level_size50[10]->in[43] mux_2level_size50[10]->in[44] mux_2level_size50[10]->in[45] mux_2level_size50[10]->in[46] mux_2level_size50[10]->in[47] mux_2level_size50[10]->in[48] mux_2level_size50[10]->in[49] mux_2level_size50[10]->out sram[160]->outb sram[160]->out sram[161]->out sram[161]->outb sram[162]->out sram[162]->outb sram[163]->out sram[163]->outb sram[164]->out sram[164]->outb sram[165]->out sram[165]->outb sram[166]->out sram[166]->outb sram[167]->out sram[167]->outb sram[168]->outb sram[168]->out sram[169]->out sram[169]->outb sram[170]->out sram[170]->outb sram[171]->out sram[171]->outb sram[172]->out sram[172]->outb sram[173]->out sram[173]->outb sram[174]->out sram[174]->outb sram[175]->out sram[175]->outb gvdd_mux_2level_size50[10] 0 mux_2level_size50
***** SRAM bits for MUX[10], level=2, select_path_id=0. *****
*****1000000010000000*****
Xsram[160] sram->in sram[160]->out sram[160]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[160]->out) 0
.nodeset V(sram[160]->outb) vsp
Xsram[161] sram->in sram[161]->out sram[161]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[161]->out) 0
.nodeset V(sram[161]->outb) vsp
Xsram[162] sram->in sram[162]->out sram[162]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[162]->out) 0
.nodeset V(sram[162]->outb) vsp
Xsram[163] sram->in sram[163]->out sram[163]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[163]->out) 0
.nodeset V(sram[163]->outb) vsp
Xsram[164] sram->in sram[164]->out sram[164]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[164]->out) 0
.nodeset V(sram[164]->outb) vsp
Xsram[165] sram->in sram[165]->out sram[165]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[165]->out) 0
.nodeset V(sram[165]->outb) vsp
Xsram[166] sram->in sram[166]->out sram[166]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[166]->out) 0
.nodeset V(sram[166]->outb) vsp
Xsram[167] sram->in sram[167]->out sram[167]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[167]->out) 0
.nodeset V(sram[167]->outb) vsp
Xsram[168] sram->in sram[168]->out sram[168]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[168]->out) 0
.nodeset V(sram[168]->outb) vsp
Xsram[169] sram->in sram[169]->out sram[169]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[169]->out) 0
.nodeset V(sram[169]->outb) vsp
Xsram[170] sram->in sram[170]->out sram[170]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[170]->out) 0
.nodeset V(sram[170]->outb) vsp
Xsram[171] sram->in sram[171]->out sram[171]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[171]->out) 0
.nodeset V(sram[171]->outb) vsp
Xsram[172] sram->in sram[172]->out sram[172]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[172]->out) 0
.nodeset V(sram[172]->outb) vsp
Xsram[173] sram->in sram[173]->out sram[173]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[173]->out) 0
.nodeset V(sram[173]->outb) vsp
Xsram[174] sram->in sram[174]->out sram[174]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[174]->out) 0
.nodeset V(sram[174]->outb) vsp
Xsram[175] sram->in sram[175]->out sram[175]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[175]->out) 0
.nodeset V(sram[175]->outb) vsp
***** Signal mux_2level_size50[10]->in[0] density = 0, probability=0.*****
Vmux_2level_size50[10]->in[0] mux_2level_size50[10]->in[0] 0
+  0
***** Signal mux_2level_size50[10]->in[1] density = 0, probability=0.*****
Vmux_2level_size50[10]->in[1] mux_2level_size50[10]->in[1] 0
+  0
***** Signal mux_2level_size50[10]->in[2] density = 0, probability=0.*****
Vmux_2level_size50[10]->in[2] mux_2level_size50[10]->in[2] 0
+  0
***** Signal mux_2level_size50[10]->in[3] density = 0, probability=0.*****
Vmux_2level_size50[10]->in[3] mux_2level_size50[10]->in[3] 0
+  0
***** Signal mux_2level_size50[10]->in[4] density = 0, probability=0.*****
Vmux_2level_size50[10]->in[4] mux_2level_size50[10]->in[4] 0
+  0
***** Signal mux_2level_size50[10]->in[5] density = 0, probability=0.*****
Vmux_2level_size50[10]->in[5] mux_2level_size50[10]->in[5] 0
+  0
***** Signal mux_2level_size50[10]->in[6] density = 0, probability=0.*****
Vmux_2level_size50[10]->in[6] mux_2level_size50[10]->in[6] 0
+  0
***** Signal mux_2level_size50[10]->in[7] density = 0, probability=0.*****
Vmux_2level_size50[10]->in[7] mux_2level_size50[10]->in[7] 0
+  0
***** Signal mux_2level_size50[10]->in[8] density = 0, probability=0.*****
Vmux_2level_size50[10]->in[8] mux_2level_size50[10]->in[8] 0
+  0
***** Signal mux_2level_size50[10]->in[9] density = 0, probability=0.*****
Vmux_2level_size50[10]->in[9] mux_2level_size50[10]->in[9] 0
+  0
***** Signal mux_2level_size50[10]->in[10] density = 0, probability=0.*****
Vmux_2level_size50[10]->in[10] mux_2level_size50[10]->in[10] 0
+  0
***** Signal mux_2level_size50[10]->in[11] density = 0, probability=0.*****
Vmux_2level_size50[10]->in[11] mux_2level_size50[10]->in[11] 0
+  0
***** Signal mux_2level_size50[10]->in[12] density = 0, probability=0.*****
Vmux_2level_size50[10]->in[12] mux_2level_size50[10]->in[12] 0
+  0
***** Signal mux_2level_size50[10]->in[13] density = 0, probability=0.*****
Vmux_2level_size50[10]->in[13] mux_2level_size50[10]->in[13] 0
+  0
***** Signal mux_2level_size50[10]->in[14] density = 0, probability=0.*****
Vmux_2level_size50[10]->in[14] mux_2level_size50[10]->in[14] 0
+  0
***** Signal mux_2level_size50[10]->in[15] density = 0, probability=0.*****
Vmux_2level_size50[10]->in[15] mux_2level_size50[10]->in[15] 0
+  0
***** Signal mux_2level_size50[10]->in[16] density = 0, probability=0.*****
Vmux_2level_size50[10]->in[16] mux_2level_size50[10]->in[16] 0
+  0
***** Signal mux_2level_size50[10]->in[17] density = 0, probability=0.*****
Vmux_2level_size50[10]->in[17] mux_2level_size50[10]->in[17] 0
+  0
***** Signal mux_2level_size50[10]->in[18] density = 0, probability=0.*****
Vmux_2level_size50[10]->in[18] mux_2level_size50[10]->in[18] 0
+  0
***** Signal mux_2level_size50[10]->in[19] density = 0, probability=0.*****
Vmux_2level_size50[10]->in[19] mux_2level_size50[10]->in[19] 0
+  0
***** Signal mux_2level_size50[10]->in[20] density = 0, probability=0.*****
Vmux_2level_size50[10]->in[20] mux_2level_size50[10]->in[20] 0
+  0
***** Signal mux_2level_size50[10]->in[21] density = 0, probability=0.*****
Vmux_2level_size50[10]->in[21] mux_2level_size50[10]->in[21] 0
+  0
***** Signal mux_2level_size50[10]->in[22] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[10]->in[22] mux_2level_size50[10]->in[22] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[10]->in[23] density = 0, probability=0.*****
Vmux_2level_size50[10]->in[23] mux_2level_size50[10]->in[23] 0
+  0
***** Signal mux_2level_size50[10]->in[24] density = 0, probability=0.*****
Vmux_2level_size50[10]->in[24] mux_2level_size50[10]->in[24] 0
+  0
***** Signal mux_2level_size50[10]->in[25] density = 0, probability=0.*****
Vmux_2level_size50[10]->in[25] mux_2level_size50[10]->in[25] 0
+  0
***** Signal mux_2level_size50[10]->in[26] density = 0, probability=0.*****
Vmux_2level_size50[10]->in[26] mux_2level_size50[10]->in[26] 0
+  0
***** Signal mux_2level_size50[10]->in[27] density = 0, probability=0.*****
Vmux_2level_size50[10]->in[27] mux_2level_size50[10]->in[27] 0
+  0
***** Signal mux_2level_size50[10]->in[28] density = 0, probability=0.*****
Vmux_2level_size50[10]->in[28] mux_2level_size50[10]->in[28] 0
+  0
***** Signal mux_2level_size50[10]->in[29] density = 0, probability=0.*****
Vmux_2level_size50[10]->in[29] mux_2level_size50[10]->in[29] 0
+  0
***** Signal mux_2level_size50[10]->in[30] density = 0, probability=0.*****
Vmux_2level_size50[10]->in[30] mux_2level_size50[10]->in[30] 0
+  0
***** Signal mux_2level_size50[10]->in[31] density = 0, probability=0.*****
Vmux_2level_size50[10]->in[31] mux_2level_size50[10]->in[31] 0
+  0
***** Signal mux_2level_size50[10]->in[32] density = 0, probability=0.*****
Vmux_2level_size50[10]->in[32] mux_2level_size50[10]->in[32] 0
+  0
***** Signal mux_2level_size50[10]->in[33] density = 0, probability=0.*****
Vmux_2level_size50[10]->in[33] mux_2level_size50[10]->in[33] 0
+  0
***** Signal mux_2level_size50[10]->in[34] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[10]->in[34] mux_2level_size50[10]->in[34] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[10]->in[35] density = 0, probability=0.*****
Vmux_2level_size50[10]->in[35] mux_2level_size50[10]->in[35] 0
+  0
***** Signal mux_2level_size50[10]->in[36] density = 0, probability=0.*****
Vmux_2level_size50[10]->in[36] mux_2level_size50[10]->in[36] 0
+  0
***** Signal mux_2level_size50[10]->in[37] density = 0, probability=0.*****
Vmux_2level_size50[10]->in[37] mux_2level_size50[10]->in[37] 0
+  0
***** Signal mux_2level_size50[10]->in[38] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[10]->in[38] mux_2level_size50[10]->in[38] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[10]->in[39] density = 0, probability=0.*****
Vmux_2level_size50[10]->in[39] mux_2level_size50[10]->in[39] 0
+  0
***** Signal mux_2level_size50[10]->in[40] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[10]->in[40] mux_2level_size50[10]->in[40] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[10]->in[41] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[10]->in[41] mux_2level_size50[10]->in[41] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[10]->in[42] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[10]->in[42] mux_2level_size50[10]->in[42] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[10]->in[43] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[10]->in[43] mux_2level_size50[10]->in[43] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[10]->in[44] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[10]->in[44] mux_2level_size50[10]->in[44] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[10]->in[45] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[10]->in[45] mux_2level_size50[10]->in[45] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[10]->in[46] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[10]->in[46] mux_2level_size50[10]->in[46] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[10]->in[47] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[10]->in[47] mux_2level_size50[10]->in[47] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[10]->in[48] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[10]->in[48] mux_2level_size50[10]->in[48] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[10]->in[49] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[10]->in[49] mux_2level_size50[10]->in[49] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
Vgvdd_mux_2level_size50[10] gvdd_mux_2level_size50[10] 0 vsp
***** Measurements *****
***** Rise delay *****
.meas tran delay_rise_idle_mux50[10]_in[4]_crossbar trig v(mux_2level_size50[10]->in[0]) val='input_thres_pct_rise*vsp' rise=1 td='clock_period'
+          targ v(mux_2level_size50[10]->out) val='output_thres_pct_rise*vsp' rise=1 td='clock_period'
***** Fall delay *****
.meas tran delay_fall_idle_mux50[10]_in[4]_crossbar trig v(mux_2level_size50[10]->in[0]) val='input_thres_pct_fall*vsp' fall=1 td='clock_period'
+          targ v(mux_2level_size50[10]->out) val='output_thres_pct_fall*vsp' fall=1 td='clock_period'
***** Rise timing period *****
.meas start_rise_idle_mux50[10]_in[4]_crossbar when v(mux_2level_size50[10]->in[0])='slew_lower_thres_pct_rise*vsp' rise=1 td='clock_period'
.meas tran switch_rise_idle_mux50[10]_in[4]_crossbar trig v(mux_2level_size50[10]->in[0]) val='slew_lower_thres_pct_rise*vsp' rise=1 td='clock_period'
+          targ v(mux_2level_size50[10]->out) val='slew_upper_thres_pct_rise*vsp' rise=1 td='clock_period'
***** Fall timing period *****
.meas start_fall_idle_mux50[10]_in[4]_crossbar when v(mux_2level_size50[10]->in[0])='slew_lower_thres_pct_fall*vsp' fall=1 td='clock_period'
.meas tran switch_fall_idle_mux50[10]_in[4]_crossbar trig v(mux_2level_size50[10]->in[0]) val='slew_lower_thres_pct_fall*vsp' fall=1 td='clock_period'
+          targ v(mux_2level_size50[10]->out) val='slew_upper_thres_pct_fall*vsp' fall=1 td='clock_period'
***** Leakage Power Measurement *****
.meas tran mux_2level_size50[10]_leakage_power avg p(Vgvdd_mux_2level_size50[10]) from=0 to='clock_period'
.meas tran leakage_idle_mux50[10]_in[4]_crossbar param='mux_2level_size50[10]_leakage_power'
***** Dynamic Power Measurement *****
.meas tran mux_2level_size50[10]_dynamic_power avg p(Vgvdd_mux_2level_size50[10]) from='clock_period' to='6*clock_period'
.meas tran mux_2level_size50[10]_energy_per_cycle param='mux_2level_size50[10]_dynamic_power*clock_period'
.meas tran dynamic_power_idle_mux50[10]_in[4]_crossbar  param='mux_2level_size50[10]_dynamic_power'
.meas tran energy_per_cycle_idle_mux50[10]_in[4]_crossbar  param='dynamic_power_idle_mux50[10]_in[4]_crossbar*clock_period'
.meas tran dynamic_rise_idle_mux50[10]_in[4]_crossbar avg p(Vgvdd_mux_2level_size50[10]) from='start_rise_idle_mux50[10]_in[4]_crossbar' to='start_rise_idle_mux50[10]_in[4]_crossbar+switch_rise_idle_mux50[10]_in[4]_crossbar'
.meas tran dynamic_fall_idle_mux50[10]_in[4]_crossbar avg p(Vgvdd_mux_2level_size50[10]) from='start_fall_idle_mux50[10]_in[4]_crossbar' to='start_fall_idle_mux50[10]_in[4]_crossbar+switch_fall_idle_mux50[10]_in[4]_crossbar'
.meas tran sum_leakage_power_mux[0to10]
+          param='sum_leakage_power_mux[0to9]+leakage_idle_mux50[10]_in[4]_crossbar'
.meas tran sum_energy_per_cycle_mux[0to10]
+          param='sum_energy_per_cycle_mux[0to9]+energy_per_cycle_idle_mux50[10]_in[4]_crossbar'
Xload_inv[10]_no0 mux_2level_size50[10]->out mux_2level_size50[10]->out_out[0] gvdd_load 0 inv size=5
.meas tran sum_leakage_power_pb_mux[0to10]
+          param='sum_leakage_power_pb_mux[0to9]+leakage_idle_mux50[10]_in[4]_crossbar'
.meas tran sum_energy_per_cycle_pb_mux[0to10]
+          param='sum_energy_per_cycle_pb_mux[0to9]+energy_per_cycle_idle_mux50[10]_in[4]_crossbar'
Xmux_2level_size50[11] mux_2level_size50[11]->in[0] mux_2level_size50[11]->in[1] mux_2level_size50[11]->in[2] mux_2level_size50[11]->in[3] mux_2level_size50[11]->in[4] mux_2level_size50[11]->in[5] mux_2level_size50[11]->in[6] mux_2level_size50[11]->in[7] mux_2level_size50[11]->in[8] mux_2level_size50[11]->in[9] mux_2level_size50[11]->in[10] mux_2level_size50[11]->in[11] mux_2level_size50[11]->in[12] mux_2level_size50[11]->in[13] mux_2level_size50[11]->in[14] mux_2level_size50[11]->in[15] mux_2level_size50[11]->in[16] mux_2level_size50[11]->in[17] mux_2level_size50[11]->in[18] mux_2level_size50[11]->in[19] mux_2level_size50[11]->in[20] mux_2level_size50[11]->in[21] mux_2level_size50[11]->in[22] mux_2level_size50[11]->in[23] mux_2level_size50[11]->in[24] mux_2level_size50[11]->in[25] mux_2level_size50[11]->in[26] mux_2level_size50[11]->in[27] mux_2level_size50[11]->in[28] mux_2level_size50[11]->in[29] mux_2level_size50[11]->in[30] mux_2level_size50[11]->in[31] mux_2level_size50[11]->in[32] mux_2level_size50[11]->in[33] mux_2level_size50[11]->in[34] mux_2level_size50[11]->in[35] mux_2level_size50[11]->in[36] mux_2level_size50[11]->in[37] mux_2level_size50[11]->in[38] mux_2level_size50[11]->in[39] mux_2level_size50[11]->in[40] mux_2level_size50[11]->in[41] mux_2level_size50[11]->in[42] mux_2level_size50[11]->in[43] mux_2level_size50[11]->in[44] mux_2level_size50[11]->in[45] mux_2level_size50[11]->in[46] mux_2level_size50[11]->in[47] mux_2level_size50[11]->in[48] mux_2level_size50[11]->in[49] mux_2level_size50[11]->out sram[176]->outb sram[176]->out sram[177]->out sram[177]->outb sram[178]->out sram[178]->outb sram[179]->out sram[179]->outb sram[180]->out sram[180]->outb sram[181]->out sram[181]->outb sram[182]->out sram[182]->outb sram[183]->out sram[183]->outb sram[184]->outb sram[184]->out sram[185]->out sram[185]->outb sram[186]->out sram[186]->outb sram[187]->out sram[187]->outb sram[188]->out sram[188]->outb sram[189]->out sram[189]->outb sram[190]->out sram[190]->outb sram[191]->out sram[191]->outb gvdd_mux_2level_size50[11] 0 mux_2level_size50
***** SRAM bits for MUX[11], level=2, select_path_id=0. *****
*****1000000010000000*****
Xsram[176] sram->in sram[176]->out sram[176]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[176]->out) 0
.nodeset V(sram[176]->outb) vsp
Xsram[177] sram->in sram[177]->out sram[177]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[177]->out) 0
.nodeset V(sram[177]->outb) vsp
Xsram[178] sram->in sram[178]->out sram[178]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[178]->out) 0
.nodeset V(sram[178]->outb) vsp
Xsram[179] sram->in sram[179]->out sram[179]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[179]->out) 0
.nodeset V(sram[179]->outb) vsp
Xsram[180] sram->in sram[180]->out sram[180]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[180]->out) 0
.nodeset V(sram[180]->outb) vsp
Xsram[181] sram->in sram[181]->out sram[181]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[181]->out) 0
.nodeset V(sram[181]->outb) vsp
Xsram[182] sram->in sram[182]->out sram[182]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[182]->out) 0
.nodeset V(sram[182]->outb) vsp
Xsram[183] sram->in sram[183]->out sram[183]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[183]->out) 0
.nodeset V(sram[183]->outb) vsp
Xsram[184] sram->in sram[184]->out sram[184]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[184]->out) 0
.nodeset V(sram[184]->outb) vsp
Xsram[185] sram->in sram[185]->out sram[185]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[185]->out) 0
.nodeset V(sram[185]->outb) vsp
Xsram[186] sram->in sram[186]->out sram[186]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[186]->out) 0
.nodeset V(sram[186]->outb) vsp
Xsram[187] sram->in sram[187]->out sram[187]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[187]->out) 0
.nodeset V(sram[187]->outb) vsp
Xsram[188] sram->in sram[188]->out sram[188]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[188]->out) 0
.nodeset V(sram[188]->outb) vsp
Xsram[189] sram->in sram[189]->out sram[189]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[189]->out) 0
.nodeset V(sram[189]->outb) vsp
Xsram[190] sram->in sram[190]->out sram[190]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[190]->out) 0
.nodeset V(sram[190]->outb) vsp
Xsram[191] sram->in sram[191]->out sram[191]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[191]->out) 0
.nodeset V(sram[191]->outb) vsp
***** Signal mux_2level_size50[11]->in[0] density = 0, probability=0.*****
Vmux_2level_size50[11]->in[0] mux_2level_size50[11]->in[0] 0
+  0
***** Signal mux_2level_size50[11]->in[1] density = 0, probability=0.*****
Vmux_2level_size50[11]->in[1] mux_2level_size50[11]->in[1] 0
+  0
***** Signal mux_2level_size50[11]->in[2] density = 0, probability=0.*****
Vmux_2level_size50[11]->in[2] mux_2level_size50[11]->in[2] 0
+  0
***** Signal mux_2level_size50[11]->in[3] density = 0, probability=0.*****
Vmux_2level_size50[11]->in[3] mux_2level_size50[11]->in[3] 0
+  0
***** Signal mux_2level_size50[11]->in[4] density = 0, probability=0.*****
Vmux_2level_size50[11]->in[4] mux_2level_size50[11]->in[4] 0
+  0
***** Signal mux_2level_size50[11]->in[5] density = 0, probability=0.*****
Vmux_2level_size50[11]->in[5] mux_2level_size50[11]->in[5] 0
+  0
***** Signal mux_2level_size50[11]->in[6] density = 0, probability=0.*****
Vmux_2level_size50[11]->in[6] mux_2level_size50[11]->in[6] 0
+  0
***** Signal mux_2level_size50[11]->in[7] density = 0, probability=0.*****
Vmux_2level_size50[11]->in[7] mux_2level_size50[11]->in[7] 0
+  0
***** Signal mux_2level_size50[11]->in[8] density = 0, probability=0.*****
Vmux_2level_size50[11]->in[8] mux_2level_size50[11]->in[8] 0
+  0
***** Signal mux_2level_size50[11]->in[9] density = 0, probability=0.*****
Vmux_2level_size50[11]->in[9] mux_2level_size50[11]->in[9] 0
+  0
***** Signal mux_2level_size50[11]->in[10] density = 0, probability=0.*****
Vmux_2level_size50[11]->in[10] mux_2level_size50[11]->in[10] 0
+  0
***** Signal mux_2level_size50[11]->in[11] density = 0, probability=0.*****
Vmux_2level_size50[11]->in[11] mux_2level_size50[11]->in[11] 0
+  0
***** Signal mux_2level_size50[11]->in[12] density = 0, probability=0.*****
Vmux_2level_size50[11]->in[12] mux_2level_size50[11]->in[12] 0
+  0
***** Signal mux_2level_size50[11]->in[13] density = 0, probability=0.*****
Vmux_2level_size50[11]->in[13] mux_2level_size50[11]->in[13] 0
+  0
***** Signal mux_2level_size50[11]->in[14] density = 0, probability=0.*****
Vmux_2level_size50[11]->in[14] mux_2level_size50[11]->in[14] 0
+  0
***** Signal mux_2level_size50[11]->in[15] density = 0, probability=0.*****
Vmux_2level_size50[11]->in[15] mux_2level_size50[11]->in[15] 0
+  0
***** Signal mux_2level_size50[11]->in[16] density = 0, probability=0.*****
Vmux_2level_size50[11]->in[16] mux_2level_size50[11]->in[16] 0
+  0
***** Signal mux_2level_size50[11]->in[17] density = 0, probability=0.*****
Vmux_2level_size50[11]->in[17] mux_2level_size50[11]->in[17] 0
+  0
***** Signal mux_2level_size50[11]->in[18] density = 0, probability=0.*****
Vmux_2level_size50[11]->in[18] mux_2level_size50[11]->in[18] 0
+  0
***** Signal mux_2level_size50[11]->in[19] density = 0, probability=0.*****
Vmux_2level_size50[11]->in[19] mux_2level_size50[11]->in[19] 0
+  0
***** Signal mux_2level_size50[11]->in[20] density = 0, probability=0.*****
Vmux_2level_size50[11]->in[20] mux_2level_size50[11]->in[20] 0
+  0
***** Signal mux_2level_size50[11]->in[21] density = 0, probability=0.*****
Vmux_2level_size50[11]->in[21] mux_2level_size50[11]->in[21] 0
+  0
***** Signal mux_2level_size50[11]->in[22] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[11]->in[22] mux_2level_size50[11]->in[22] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[11]->in[23] density = 0, probability=0.*****
Vmux_2level_size50[11]->in[23] mux_2level_size50[11]->in[23] 0
+  0
***** Signal mux_2level_size50[11]->in[24] density = 0, probability=0.*****
Vmux_2level_size50[11]->in[24] mux_2level_size50[11]->in[24] 0
+  0
***** Signal mux_2level_size50[11]->in[25] density = 0, probability=0.*****
Vmux_2level_size50[11]->in[25] mux_2level_size50[11]->in[25] 0
+  0
***** Signal mux_2level_size50[11]->in[26] density = 0, probability=0.*****
Vmux_2level_size50[11]->in[26] mux_2level_size50[11]->in[26] 0
+  0
***** Signal mux_2level_size50[11]->in[27] density = 0, probability=0.*****
Vmux_2level_size50[11]->in[27] mux_2level_size50[11]->in[27] 0
+  0
***** Signal mux_2level_size50[11]->in[28] density = 0, probability=0.*****
Vmux_2level_size50[11]->in[28] mux_2level_size50[11]->in[28] 0
+  0
***** Signal mux_2level_size50[11]->in[29] density = 0, probability=0.*****
Vmux_2level_size50[11]->in[29] mux_2level_size50[11]->in[29] 0
+  0
***** Signal mux_2level_size50[11]->in[30] density = 0, probability=0.*****
Vmux_2level_size50[11]->in[30] mux_2level_size50[11]->in[30] 0
+  0
***** Signal mux_2level_size50[11]->in[31] density = 0, probability=0.*****
Vmux_2level_size50[11]->in[31] mux_2level_size50[11]->in[31] 0
+  0
***** Signal mux_2level_size50[11]->in[32] density = 0, probability=0.*****
Vmux_2level_size50[11]->in[32] mux_2level_size50[11]->in[32] 0
+  0
***** Signal mux_2level_size50[11]->in[33] density = 0, probability=0.*****
Vmux_2level_size50[11]->in[33] mux_2level_size50[11]->in[33] 0
+  0
***** Signal mux_2level_size50[11]->in[34] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[11]->in[34] mux_2level_size50[11]->in[34] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[11]->in[35] density = 0, probability=0.*****
Vmux_2level_size50[11]->in[35] mux_2level_size50[11]->in[35] 0
+  0
***** Signal mux_2level_size50[11]->in[36] density = 0, probability=0.*****
Vmux_2level_size50[11]->in[36] mux_2level_size50[11]->in[36] 0
+  0
***** Signal mux_2level_size50[11]->in[37] density = 0, probability=0.*****
Vmux_2level_size50[11]->in[37] mux_2level_size50[11]->in[37] 0
+  0
***** Signal mux_2level_size50[11]->in[38] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[11]->in[38] mux_2level_size50[11]->in[38] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[11]->in[39] density = 0, probability=0.*****
Vmux_2level_size50[11]->in[39] mux_2level_size50[11]->in[39] 0
+  0
***** Signal mux_2level_size50[11]->in[40] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[11]->in[40] mux_2level_size50[11]->in[40] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[11]->in[41] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[11]->in[41] mux_2level_size50[11]->in[41] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[11]->in[42] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[11]->in[42] mux_2level_size50[11]->in[42] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[11]->in[43] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[11]->in[43] mux_2level_size50[11]->in[43] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[11]->in[44] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[11]->in[44] mux_2level_size50[11]->in[44] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[11]->in[45] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[11]->in[45] mux_2level_size50[11]->in[45] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[11]->in[46] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[11]->in[46] mux_2level_size50[11]->in[46] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[11]->in[47] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[11]->in[47] mux_2level_size50[11]->in[47] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[11]->in[48] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[11]->in[48] mux_2level_size50[11]->in[48] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[11]->in[49] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[11]->in[49] mux_2level_size50[11]->in[49] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
Vgvdd_mux_2level_size50[11] gvdd_mux_2level_size50[11] 0 vsp
***** Measurements *****
***** Rise delay *****
.meas tran delay_rise_idle_mux50[11]_in[5]_crossbar trig v(mux_2level_size50[11]->in[0]) val='input_thres_pct_rise*vsp' rise=1 td='clock_period'
+          targ v(mux_2level_size50[11]->out) val='output_thres_pct_rise*vsp' rise=1 td='clock_period'
***** Fall delay *****
.meas tran delay_fall_idle_mux50[11]_in[5]_crossbar trig v(mux_2level_size50[11]->in[0]) val='input_thres_pct_fall*vsp' fall=1 td='clock_period'
+          targ v(mux_2level_size50[11]->out) val='output_thres_pct_fall*vsp' fall=1 td='clock_period'
***** Rise timing period *****
.meas start_rise_idle_mux50[11]_in[5]_crossbar when v(mux_2level_size50[11]->in[0])='slew_lower_thres_pct_rise*vsp' rise=1 td='clock_period'
.meas tran switch_rise_idle_mux50[11]_in[5]_crossbar trig v(mux_2level_size50[11]->in[0]) val='slew_lower_thres_pct_rise*vsp' rise=1 td='clock_period'
+          targ v(mux_2level_size50[11]->out) val='slew_upper_thres_pct_rise*vsp' rise=1 td='clock_period'
***** Fall timing period *****
.meas start_fall_idle_mux50[11]_in[5]_crossbar when v(mux_2level_size50[11]->in[0])='slew_lower_thres_pct_fall*vsp' fall=1 td='clock_period'
.meas tran switch_fall_idle_mux50[11]_in[5]_crossbar trig v(mux_2level_size50[11]->in[0]) val='slew_lower_thres_pct_fall*vsp' fall=1 td='clock_period'
+          targ v(mux_2level_size50[11]->out) val='slew_upper_thres_pct_fall*vsp' fall=1 td='clock_period'
***** Leakage Power Measurement *****
.meas tran mux_2level_size50[11]_leakage_power avg p(Vgvdd_mux_2level_size50[11]) from=0 to='clock_period'
.meas tran leakage_idle_mux50[11]_in[5]_crossbar param='mux_2level_size50[11]_leakage_power'
***** Dynamic Power Measurement *****
.meas tran mux_2level_size50[11]_dynamic_power avg p(Vgvdd_mux_2level_size50[11]) from='clock_period' to='6*clock_period'
.meas tran mux_2level_size50[11]_energy_per_cycle param='mux_2level_size50[11]_dynamic_power*clock_period'
.meas tran dynamic_power_idle_mux50[11]_in[5]_crossbar  param='mux_2level_size50[11]_dynamic_power'
.meas tran energy_per_cycle_idle_mux50[11]_in[5]_crossbar  param='dynamic_power_idle_mux50[11]_in[5]_crossbar*clock_period'
.meas tran dynamic_rise_idle_mux50[11]_in[5]_crossbar avg p(Vgvdd_mux_2level_size50[11]) from='start_rise_idle_mux50[11]_in[5]_crossbar' to='start_rise_idle_mux50[11]_in[5]_crossbar+switch_rise_idle_mux50[11]_in[5]_crossbar'
.meas tran dynamic_fall_idle_mux50[11]_in[5]_crossbar avg p(Vgvdd_mux_2level_size50[11]) from='start_fall_idle_mux50[11]_in[5]_crossbar' to='start_fall_idle_mux50[11]_in[5]_crossbar+switch_fall_idle_mux50[11]_in[5]_crossbar'
.meas tran sum_leakage_power_mux[0to11]
+          param='sum_leakage_power_mux[0to10]+leakage_idle_mux50[11]_in[5]_crossbar'
.meas tran sum_energy_per_cycle_mux[0to11]
+          param='sum_energy_per_cycle_mux[0to10]+energy_per_cycle_idle_mux50[11]_in[5]_crossbar'
Xload_inv[11]_no0 mux_2level_size50[11]->out mux_2level_size50[11]->out_out[0] gvdd_load 0 inv size=5
.meas tran sum_leakage_power_pb_mux[0to11]
+          param='sum_leakage_power_pb_mux[0to10]+leakage_idle_mux50[11]_in[5]_crossbar'
.meas tran sum_energy_per_cycle_pb_mux[0to11]
+          param='sum_energy_per_cycle_pb_mux[0to10]+energy_per_cycle_idle_mux50[11]_in[5]_crossbar'
Xmux_2level_size50[12] mux_2level_size50[12]->in[0] mux_2level_size50[12]->in[1] mux_2level_size50[12]->in[2] mux_2level_size50[12]->in[3] mux_2level_size50[12]->in[4] mux_2level_size50[12]->in[5] mux_2level_size50[12]->in[6] mux_2level_size50[12]->in[7] mux_2level_size50[12]->in[8] mux_2level_size50[12]->in[9] mux_2level_size50[12]->in[10] mux_2level_size50[12]->in[11] mux_2level_size50[12]->in[12] mux_2level_size50[12]->in[13] mux_2level_size50[12]->in[14] mux_2level_size50[12]->in[15] mux_2level_size50[12]->in[16] mux_2level_size50[12]->in[17] mux_2level_size50[12]->in[18] mux_2level_size50[12]->in[19] mux_2level_size50[12]->in[20] mux_2level_size50[12]->in[21] mux_2level_size50[12]->in[22] mux_2level_size50[12]->in[23] mux_2level_size50[12]->in[24] mux_2level_size50[12]->in[25] mux_2level_size50[12]->in[26] mux_2level_size50[12]->in[27] mux_2level_size50[12]->in[28] mux_2level_size50[12]->in[29] mux_2level_size50[12]->in[30] mux_2level_size50[12]->in[31] mux_2level_size50[12]->in[32] mux_2level_size50[12]->in[33] mux_2level_size50[12]->in[34] mux_2level_size50[12]->in[35] mux_2level_size50[12]->in[36] mux_2level_size50[12]->in[37] mux_2level_size50[12]->in[38] mux_2level_size50[12]->in[39] mux_2level_size50[12]->in[40] mux_2level_size50[12]->in[41] mux_2level_size50[12]->in[42] mux_2level_size50[12]->in[43] mux_2level_size50[12]->in[44] mux_2level_size50[12]->in[45] mux_2level_size50[12]->in[46] mux_2level_size50[12]->in[47] mux_2level_size50[12]->in[48] mux_2level_size50[12]->in[49] mux_2level_size50[12]->out sram[192]->outb sram[192]->out sram[193]->out sram[193]->outb sram[194]->out sram[194]->outb sram[195]->out sram[195]->outb sram[196]->out sram[196]->outb sram[197]->out sram[197]->outb sram[198]->out sram[198]->outb sram[199]->out sram[199]->outb sram[200]->outb sram[200]->out sram[201]->out sram[201]->outb sram[202]->out sram[202]->outb sram[203]->out sram[203]->outb sram[204]->out sram[204]->outb sram[205]->out sram[205]->outb sram[206]->out sram[206]->outb sram[207]->out sram[207]->outb gvdd_mux_2level_size50[12] 0 mux_2level_size50
***** SRAM bits for MUX[12], level=2, select_path_id=0. *****
*****1000000010000000*****
Xsram[192] sram->in sram[192]->out sram[192]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[192]->out) 0
.nodeset V(sram[192]->outb) vsp
Xsram[193] sram->in sram[193]->out sram[193]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[193]->out) 0
.nodeset V(sram[193]->outb) vsp
Xsram[194] sram->in sram[194]->out sram[194]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[194]->out) 0
.nodeset V(sram[194]->outb) vsp
Xsram[195] sram->in sram[195]->out sram[195]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[195]->out) 0
.nodeset V(sram[195]->outb) vsp
Xsram[196] sram->in sram[196]->out sram[196]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[196]->out) 0
.nodeset V(sram[196]->outb) vsp
Xsram[197] sram->in sram[197]->out sram[197]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[197]->out) 0
.nodeset V(sram[197]->outb) vsp
Xsram[198] sram->in sram[198]->out sram[198]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[198]->out) 0
.nodeset V(sram[198]->outb) vsp
Xsram[199] sram->in sram[199]->out sram[199]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[199]->out) 0
.nodeset V(sram[199]->outb) vsp
Xsram[200] sram->in sram[200]->out sram[200]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[200]->out) 0
.nodeset V(sram[200]->outb) vsp
Xsram[201] sram->in sram[201]->out sram[201]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[201]->out) 0
.nodeset V(sram[201]->outb) vsp
Xsram[202] sram->in sram[202]->out sram[202]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[202]->out) 0
.nodeset V(sram[202]->outb) vsp
Xsram[203] sram->in sram[203]->out sram[203]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[203]->out) 0
.nodeset V(sram[203]->outb) vsp
Xsram[204] sram->in sram[204]->out sram[204]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[204]->out) 0
.nodeset V(sram[204]->outb) vsp
Xsram[205] sram->in sram[205]->out sram[205]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[205]->out) 0
.nodeset V(sram[205]->outb) vsp
Xsram[206] sram->in sram[206]->out sram[206]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[206]->out) 0
.nodeset V(sram[206]->outb) vsp
Xsram[207] sram->in sram[207]->out sram[207]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[207]->out) 0
.nodeset V(sram[207]->outb) vsp
***** Signal mux_2level_size50[12]->in[0] density = 0, probability=0.*****
Vmux_2level_size50[12]->in[0] mux_2level_size50[12]->in[0] 0
+  0
***** Signal mux_2level_size50[12]->in[1] density = 0, probability=0.*****
Vmux_2level_size50[12]->in[1] mux_2level_size50[12]->in[1] 0
+  0
***** Signal mux_2level_size50[12]->in[2] density = 0, probability=0.*****
Vmux_2level_size50[12]->in[2] mux_2level_size50[12]->in[2] 0
+  0
***** Signal mux_2level_size50[12]->in[3] density = 0, probability=0.*****
Vmux_2level_size50[12]->in[3] mux_2level_size50[12]->in[3] 0
+  0
***** Signal mux_2level_size50[12]->in[4] density = 0, probability=0.*****
Vmux_2level_size50[12]->in[4] mux_2level_size50[12]->in[4] 0
+  0
***** Signal mux_2level_size50[12]->in[5] density = 0, probability=0.*****
Vmux_2level_size50[12]->in[5] mux_2level_size50[12]->in[5] 0
+  0
***** Signal mux_2level_size50[12]->in[6] density = 0, probability=0.*****
Vmux_2level_size50[12]->in[6] mux_2level_size50[12]->in[6] 0
+  0
***** Signal mux_2level_size50[12]->in[7] density = 0, probability=0.*****
Vmux_2level_size50[12]->in[7] mux_2level_size50[12]->in[7] 0
+  0
***** Signal mux_2level_size50[12]->in[8] density = 0, probability=0.*****
Vmux_2level_size50[12]->in[8] mux_2level_size50[12]->in[8] 0
+  0
***** Signal mux_2level_size50[12]->in[9] density = 0, probability=0.*****
Vmux_2level_size50[12]->in[9] mux_2level_size50[12]->in[9] 0
+  0
***** Signal mux_2level_size50[12]->in[10] density = 0, probability=0.*****
Vmux_2level_size50[12]->in[10] mux_2level_size50[12]->in[10] 0
+  0
***** Signal mux_2level_size50[12]->in[11] density = 0, probability=0.*****
Vmux_2level_size50[12]->in[11] mux_2level_size50[12]->in[11] 0
+  0
***** Signal mux_2level_size50[12]->in[12] density = 0, probability=0.*****
Vmux_2level_size50[12]->in[12] mux_2level_size50[12]->in[12] 0
+  0
***** Signal mux_2level_size50[12]->in[13] density = 0, probability=0.*****
Vmux_2level_size50[12]->in[13] mux_2level_size50[12]->in[13] 0
+  0
***** Signal mux_2level_size50[12]->in[14] density = 0, probability=0.*****
Vmux_2level_size50[12]->in[14] mux_2level_size50[12]->in[14] 0
+  0
***** Signal mux_2level_size50[12]->in[15] density = 0, probability=0.*****
Vmux_2level_size50[12]->in[15] mux_2level_size50[12]->in[15] 0
+  0
***** Signal mux_2level_size50[12]->in[16] density = 0, probability=0.*****
Vmux_2level_size50[12]->in[16] mux_2level_size50[12]->in[16] 0
+  0
***** Signal mux_2level_size50[12]->in[17] density = 0, probability=0.*****
Vmux_2level_size50[12]->in[17] mux_2level_size50[12]->in[17] 0
+  0
***** Signal mux_2level_size50[12]->in[18] density = 0, probability=0.*****
Vmux_2level_size50[12]->in[18] mux_2level_size50[12]->in[18] 0
+  0
***** Signal mux_2level_size50[12]->in[19] density = 0, probability=0.*****
Vmux_2level_size50[12]->in[19] mux_2level_size50[12]->in[19] 0
+  0
***** Signal mux_2level_size50[12]->in[20] density = 0, probability=0.*****
Vmux_2level_size50[12]->in[20] mux_2level_size50[12]->in[20] 0
+  0
***** Signal mux_2level_size50[12]->in[21] density = 0, probability=0.*****
Vmux_2level_size50[12]->in[21] mux_2level_size50[12]->in[21] 0
+  0
***** Signal mux_2level_size50[12]->in[22] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[12]->in[22] mux_2level_size50[12]->in[22] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[12]->in[23] density = 0, probability=0.*****
Vmux_2level_size50[12]->in[23] mux_2level_size50[12]->in[23] 0
+  0
***** Signal mux_2level_size50[12]->in[24] density = 0, probability=0.*****
Vmux_2level_size50[12]->in[24] mux_2level_size50[12]->in[24] 0
+  0
***** Signal mux_2level_size50[12]->in[25] density = 0, probability=0.*****
Vmux_2level_size50[12]->in[25] mux_2level_size50[12]->in[25] 0
+  0
***** Signal mux_2level_size50[12]->in[26] density = 0, probability=0.*****
Vmux_2level_size50[12]->in[26] mux_2level_size50[12]->in[26] 0
+  0
***** Signal mux_2level_size50[12]->in[27] density = 0, probability=0.*****
Vmux_2level_size50[12]->in[27] mux_2level_size50[12]->in[27] 0
+  0
***** Signal mux_2level_size50[12]->in[28] density = 0, probability=0.*****
Vmux_2level_size50[12]->in[28] mux_2level_size50[12]->in[28] 0
+  0
***** Signal mux_2level_size50[12]->in[29] density = 0, probability=0.*****
Vmux_2level_size50[12]->in[29] mux_2level_size50[12]->in[29] 0
+  0
***** Signal mux_2level_size50[12]->in[30] density = 0, probability=0.*****
Vmux_2level_size50[12]->in[30] mux_2level_size50[12]->in[30] 0
+  0
***** Signal mux_2level_size50[12]->in[31] density = 0, probability=0.*****
Vmux_2level_size50[12]->in[31] mux_2level_size50[12]->in[31] 0
+  0
***** Signal mux_2level_size50[12]->in[32] density = 0, probability=0.*****
Vmux_2level_size50[12]->in[32] mux_2level_size50[12]->in[32] 0
+  0
***** Signal mux_2level_size50[12]->in[33] density = 0, probability=0.*****
Vmux_2level_size50[12]->in[33] mux_2level_size50[12]->in[33] 0
+  0
***** Signal mux_2level_size50[12]->in[34] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[12]->in[34] mux_2level_size50[12]->in[34] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[12]->in[35] density = 0, probability=0.*****
Vmux_2level_size50[12]->in[35] mux_2level_size50[12]->in[35] 0
+  0
***** Signal mux_2level_size50[12]->in[36] density = 0, probability=0.*****
Vmux_2level_size50[12]->in[36] mux_2level_size50[12]->in[36] 0
+  0
***** Signal mux_2level_size50[12]->in[37] density = 0, probability=0.*****
Vmux_2level_size50[12]->in[37] mux_2level_size50[12]->in[37] 0
+  0
***** Signal mux_2level_size50[12]->in[38] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[12]->in[38] mux_2level_size50[12]->in[38] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[12]->in[39] density = 0, probability=0.*****
Vmux_2level_size50[12]->in[39] mux_2level_size50[12]->in[39] 0
+  0
***** Signal mux_2level_size50[12]->in[40] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[12]->in[40] mux_2level_size50[12]->in[40] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[12]->in[41] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[12]->in[41] mux_2level_size50[12]->in[41] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[12]->in[42] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[12]->in[42] mux_2level_size50[12]->in[42] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[12]->in[43] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[12]->in[43] mux_2level_size50[12]->in[43] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[12]->in[44] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[12]->in[44] mux_2level_size50[12]->in[44] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[12]->in[45] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[12]->in[45] mux_2level_size50[12]->in[45] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[12]->in[46] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[12]->in[46] mux_2level_size50[12]->in[46] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[12]->in[47] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[12]->in[47] mux_2level_size50[12]->in[47] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[12]->in[48] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[12]->in[48] mux_2level_size50[12]->in[48] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[12]->in[49] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[12]->in[49] mux_2level_size50[12]->in[49] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
Vgvdd_mux_2level_size50[12] gvdd_mux_2level_size50[12] 0 vsp
***** Measurements *****
***** Rise delay *****
.meas tran delay_rise_idle_mux50[12]_in[0]_crossbar trig v(mux_2level_size50[12]->in[0]) val='input_thres_pct_rise*vsp' rise=1 td='clock_period'
+          targ v(mux_2level_size50[12]->out) val='output_thres_pct_rise*vsp' rise=1 td='clock_period'
***** Fall delay *****
.meas tran delay_fall_idle_mux50[12]_in[0]_crossbar trig v(mux_2level_size50[12]->in[0]) val='input_thres_pct_fall*vsp' fall=1 td='clock_period'
+          targ v(mux_2level_size50[12]->out) val='output_thres_pct_fall*vsp' fall=1 td='clock_period'
***** Rise timing period *****
.meas start_rise_idle_mux50[12]_in[0]_crossbar when v(mux_2level_size50[12]->in[0])='slew_lower_thres_pct_rise*vsp' rise=1 td='clock_period'
.meas tran switch_rise_idle_mux50[12]_in[0]_crossbar trig v(mux_2level_size50[12]->in[0]) val='slew_lower_thres_pct_rise*vsp' rise=1 td='clock_period'
+          targ v(mux_2level_size50[12]->out) val='slew_upper_thres_pct_rise*vsp' rise=1 td='clock_period'
***** Fall timing period *****
.meas start_fall_idle_mux50[12]_in[0]_crossbar when v(mux_2level_size50[12]->in[0])='slew_lower_thres_pct_fall*vsp' fall=1 td='clock_period'
.meas tran switch_fall_idle_mux50[12]_in[0]_crossbar trig v(mux_2level_size50[12]->in[0]) val='slew_lower_thres_pct_fall*vsp' fall=1 td='clock_period'
+          targ v(mux_2level_size50[12]->out) val='slew_upper_thres_pct_fall*vsp' fall=1 td='clock_period'
***** Leakage Power Measurement *****
.meas tran mux_2level_size50[12]_leakage_power avg p(Vgvdd_mux_2level_size50[12]) from=0 to='clock_period'
.meas tran leakage_idle_mux50[12]_in[0]_crossbar param='mux_2level_size50[12]_leakage_power'
***** Dynamic Power Measurement *****
.meas tran mux_2level_size50[12]_dynamic_power avg p(Vgvdd_mux_2level_size50[12]) from='clock_period' to='6*clock_period'
.meas tran mux_2level_size50[12]_energy_per_cycle param='mux_2level_size50[12]_dynamic_power*clock_period'
.meas tran dynamic_power_idle_mux50[12]_in[0]_crossbar  param='mux_2level_size50[12]_dynamic_power'
.meas tran energy_per_cycle_idle_mux50[12]_in[0]_crossbar  param='dynamic_power_idle_mux50[12]_in[0]_crossbar*clock_period'
.meas tran dynamic_rise_idle_mux50[12]_in[0]_crossbar avg p(Vgvdd_mux_2level_size50[12]) from='start_rise_idle_mux50[12]_in[0]_crossbar' to='start_rise_idle_mux50[12]_in[0]_crossbar+switch_rise_idle_mux50[12]_in[0]_crossbar'
.meas tran dynamic_fall_idle_mux50[12]_in[0]_crossbar avg p(Vgvdd_mux_2level_size50[12]) from='start_fall_idle_mux50[12]_in[0]_crossbar' to='start_fall_idle_mux50[12]_in[0]_crossbar+switch_fall_idle_mux50[12]_in[0]_crossbar'
.meas tran sum_leakage_power_mux[0to12]
+          param='sum_leakage_power_mux[0to11]+leakage_idle_mux50[12]_in[0]_crossbar'
.meas tran sum_energy_per_cycle_mux[0to12]
+          param='sum_energy_per_cycle_mux[0to11]+energy_per_cycle_idle_mux50[12]_in[0]_crossbar'
Xload_inv[12]_no0 mux_2level_size50[12]->out mux_2level_size50[12]->out_out[0] gvdd_load 0 inv size=5
.meas tran sum_leakage_power_pb_mux[0to12]
+          param='sum_leakage_power_pb_mux[0to11]+leakage_idle_mux50[12]_in[0]_crossbar'
.meas tran sum_energy_per_cycle_pb_mux[0to12]
+          param='sum_energy_per_cycle_pb_mux[0to11]+energy_per_cycle_idle_mux50[12]_in[0]_crossbar'
Xmux_2level_size50[13] mux_2level_size50[13]->in[0] mux_2level_size50[13]->in[1] mux_2level_size50[13]->in[2] mux_2level_size50[13]->in[3] mux_2level_size50[13]->in[4] mux_2level_size50[13]->in[5] mux_2level_size50[13]->in[6] mux_2level_size50[13]->in[7] mux_2level_size50[13]->in[8] mux_2level_size50[13]->in[9] mux_2level_size50[13]->in[10] mux_2level_size50[13]->in[11] mux_2level_size50[13]->in[12] mux_2level_size50[13]->in[13] mux_2level_size50[13]->in[14] mux_2level_size50[13]->in[15] mux_2level_size50[13]->in[16] mux_2level_size50[13]->in[17] mux_2level_size50[13]->in[18] mux_2level_size50[13]->in[19] mux_2level_size50[13]->in[20] mux_2level_size50[13]->in[21] mux_2level_size50[13]->in[22] mux_2level_size50[13]->in[23] mux_2level_size50[13]->in[24] mux_2level_size50[13]->in[25] mux_2level_size50[13]->in[26] mux_2level_size50[13]->in[27] mux_2level_size50[13]->in[28] mux_2level_size50[13]->in[29] mux_2level_size50[13]->in[30] mux_2level_size50[13]->in[31] mux_2level_size50[13]->in[32] mux_2level_size50[13]->in[33] mux_2level_size50[13]->in[34] mux_2level_size50[13]->in[35] mux_2level_size50[13]->in[36] mux_2level_size50[13]->in[37] mux_2level_size50[13]->in[38] mux_2level_size50[13]->in[39] mux_2level_size50[13]->in[40] mux_2level_size50[13]->in[41] mux_2level_size50[13]->in[42] mux_2level_size50[13]->in[43] mux_2level_size50[13]->in[44] mux_2level_size50[13]->in[45] mux_2level_size50[13]->in[46] mux_2level_size50[13]->in[47] mux_2level_size50[13]->in[48] mux_2level_size50[13]->in[49] mux_2level_size50[13]->out sram[208]->outb sram[208]->out sram[209]->out sram[209]->outb sram[210]->out sram[210]->outb sram[211]->out sram[211]->outb sram[212]->out sram[212]->outb sram[213]->out sram[213]->outb sram[214]->out sram[214]->outb sram[215]->out sram[215]->outb sram[216]->outb sram[216]->out sram[217]->out sram[217]->outb sram[218]->out sram[218]->outb sram[219]->out sram[219]->outb sram[220]->out sram[220]->outb sram[221]->out sram[221]->outb sram[222]->out sram[222]->outb sram[223]->out sram[223]->outb gvdd_mux_2level_size50[13] 0 mux_2level_size50
***** SRAM bits for MUX[13], level=2, select_path_id=0. *****
*****1000000010000000*****
Xsram[208] sram->in sram[208]->out sram[208]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[208]->out) 0
.nodeset V(sram[208]->outb) vsp
Xsram[209] sram->in sram[209]->out sram[209]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[209]->out) 0
.nodeset V(sram[209]->outb) vsp
Xsram[210] sram->in sram[210]->out sram[210]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[210]->out) 0
.nodeset V(sram[210]->outb) vsp
Xsram[211] sram->in sram[211]->out sram[211]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[211]->out) 0
.nodeset V(sram[211]->outb) vsp
Xsram[212] sram->in sram[212]->out sram[212]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[212]->out) 0
.nodeset V(sram[212]->outb) vsp
Xsram[213] sram->in sram[213]->out sram[213]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[213]->out) 0
.nodeset V(sram[213]->outb) vsp
Xsram[214] sram->in sram[214]->out sram[214]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[214]->out) 0
.nodeset V(sram[214]->outb) vsp
Xsram[215] sram->in sram[215]->out sram[215]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[215]->out) 0
.nodeset V(sram[215]->outb) vsp
Xsram[216] sram->in sram[216]->out sram[216]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[216]->out) 0
.nodeset V(sram[216]->outb) vsp
Xsram[217] sram->in sram[217]->out sram[217]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[217]->out) 0
.nodeset V(sram[217]->outb) vsp
Xsram[218] sram->in sram[218]->out sram[218]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[218]->out) 0
.nodeset V(sram[218]->outb) vsp
Xsram[219] sram->in sram[219]->out sram[219]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[219]->out) 0
.nodeset V(sram[219]->outb) vsp
Xsram[220] sram->in sram[220]->out sram[220]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[220]->out) 0
.nodeset V(sram[220]->outb) vsp
Xsram[221] sram->in sram[221]->out sram[221]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[221]->out) 0
.nodeset V(sram[221]->outb) vsp
Xsram[222] sram->in sram[222]->out sram[222]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[222]->out) 0
.nodeset V(sram[222]->outb) vsp
Xsram[223] sram->in sram[223]->out sram[223]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[223]->out) 0
.nodeset V(sram[223]->outb) vsp
***** Signal mux_2level_size50[13]->in[0] density = 0, probability=0.*****
Vmux_2level_size50[13]->in[0] mux_2level_size50[13]->in[0] 0
+  0
***** Signal mux_2level_size50[13]->in[1] density = 0, probability=0.*****
Vmux_2level_size50[13]->in[1] mux_2level_size50[13]->in[1] 0
+  0
***** Signal mux_2level_size50[13]->in[2] density = 0, probability=0.*****
Vmux_2level_size50[13]->in[2] mux_2level_size50[13]->in[2] 0
+  0
***** Signal mux_2level_size50[13]->in[3] density = 0, probability=0.*****
Vmux_2level_size50[13]->in[3] mux_2level_size50[13]->in[3] 0
+  0
***** Signal mux_2level_size50[13]->in[4] density = 0, probability=0.*****
Vmux_2level_size50[13]->in[4] mux_2level_size50[13]->in[4] 0
+  0
***** Signal mux_2level_size50[13]->in[5] density = 0, probability=0.*****
Vmux_2level_size50[13]->in[5] mux_2level_size50[13]->in[5] 0
+  0
***** Signal mux_2level_size50[13]->in[6] density = 0, probability=0.*****
Vmux_2level_size50[13]->in[6] mux_2level_size50[13]->in[6] 0
+  0
***** Signal mux_2level_size50[13]->in[7] density = 0, probability=0.*****
Vmux_2level_size50[13]->in[7] mux_2level_size50[13]->in[7] 0
+  0
***** Signal mux_2level_size50[13]->in[8] density = 0, probability=0.*****
Vmux_2level_size50[13]->in[8] mux_2level_size50[13]->in[8] 0
+  0
***** Signal mux_2level_size50[13]->in[9] density = 0, probability=0.*****
Vmux_2level_size50[13]->in[9] mux_2level_size50[13]->in[9] 0
+  0
***** Signal mux_2level_size50[13]->in[10] density = 0, probability=0.*****
Vmux_2level_size50[13]->in[10] mux_2level_size50[13]->in[10] 0
+  0
***** Signal mux_2level_size50[13]->in[11] density = 0, probability=0.*****
Vmux_2level_size50[13]->in[11] mux_2level_size50[13]->in[11] 0
+  0
***** Signal mux_2level_size50[13]->in[12] density = 0, probability=0.*****
Vmux_2level_size50[13]->in[12] mux_2level_size50[13]->in[12] 0
+  0
***** Signal mux_2level_size50[13]->in[13] density = 0, probability=0.*****
Vmux_2level_size50[13]->in[13] mux_2level_size50[13]->in[13] 0
+  0
***** Signal mux_2level_size50[13]->in[14] density = 0, probability=0.*****
Vmux_2level_size50[13]->in[14] mux_2level_size50[13]->in[14] 0
+  0
***** Signal mux_2level_size50[13]->in[15] density = 0, probability=0.*****
Vmux_2level_size50[13]->in[15] mux_2level_size50[13]->in[15] 0
+  0
***** Signal mux_2level_size50[13]->in[16] density = 0, probability=0.*****
Vmux_2level_size50[13]->in[16] mux_2level_size50[13]->in[16] 0
+  0
***** Signal mux_2level_size50[13]->in[17] density = 0, probability=0.*****
Vmux_2level_size50[13]->in[17] mux_2level_size50[13]->in[17] 0
+  0
***** Signal mux_2level_size50[13]->in[18] density = 0, probability=0.*****
Vmux_2level_size50[13]->in[18] mux_2level_size50[13]->in[18] 0
+  0
***** Signal mux_2level_size50[13]->in[19] density = 0, probability=0.*****
Vmux_2level_size50[13]->in[19] mux_2level_size50[13]->in[19] 0
+  0
***** Signal mux_2level_size50[13]->in[20] density = 0, probability=0.*****
Vmux_2level_size50[13]->in[20] mux_2level_size50[13]->in[20] 0
+  0
***** Signal mux_2level_size50[13]->in[21] density = 0, probability=0.*****
Vmux_2level_size50[13]->in[21] mux_2level_size50[13]->in[21] 0
+  0
***** Signal mux_2level_size50[13]->in[22] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[13]->in[22] mux_2level_size50[13]->in[22] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[13]->in[23] density = 0, probability=0.*****
Vmux_2level_size50[13]->in[23] mux_2level_size50[13]->in[23] 0
+  0
***** Signal mux_2level_size50[13]->in[24] density = 0, probability=0.*****
Vmux_2level_size50[13]->in[24] mux_2level_size50[13]->in[24] 0
+  0
***** Signal mux_2level_size50[13]->in[25] density = 0, probability=0.*****
Vmux_2level_size50[13]->in[25] mux_2level_size50[13]->in[25] 0
+  0
***** Signal mux_2level_size50[13]->in[26] density = 0, probability=0.*****
Vmux_2level_size50[13]->in[26] mux_2level_size50[13]->in[26] 0
+  0
***** Signal mux_2level_size50[13]->in[27] density = 0, probability=0.*****
Vmux_2level_size50[13]->in[27] mux_2level_size50[13]->in[27] 0
+  0
***** Signal mux_2level_size50[13]->in[28] density = 0, probability=0.*****
Vmux_2level_size50[13]->in[28] mux_2level_size50[13]->in[28] 0
+  0
***** Signal mux_2level_size50[13]->in[29] density = 0, probability=0.*****
Vmux_2level_size50[13]->in[29] mux_2level_size50[13]->in[29] 0
+  0
***** Signal mux_2level_size50[13]->in[30] density = 0, probability=0.*****
Vmux_2level_size50[13]->in[30] mux_2level_size50[13]->in[30] 0
+  0
***** Signal mux_2level_size50[13]->in[31] density = 0, probability=0.*****
Vmux_2level_size50[13]->in[31] mux_2level_size50[13]->in[31] 0
+  0
***** Signal mux_2level_size50[13]->in[32] density = 0, probability=0.*****
Vmux_2level_size50[13]->in[32] mux_2level_size50[13]->in[32] 0
+  0
***** Signal mux_2level_size50[13]->in[33] density = 0, probability=0.*****
Vmux_2level_size50[13]->in[33] mux_2level_size50[13]->in[33] 0
+  0
***** Signal mux_2level_size50[13]->in[34] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[13]->in[34] mux_2level_size50[13]->in[34] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[13]->in[35] density = 0, probability=0.*****
Vmux_2level_size50[13]->in[35] mux_2level_size50[13]->in[35] 0
+  0
***** Signal mux_2level_size50[13]->in[36] density = 0, probability=0.*****
Vmux_2level_size50[13]->in[36] mux_2level_size50[13]->in[36] 0
+  0
***** Signal mux_2level_size50[13]->in[37] density = 0, probability=0.*****
Vmux_2level_size50[13]->in[37] mux_2level_size50[13]->in[37] 0
+  0
***** Signal mux_2level_size50[13]->in[38] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[13]->in[38] mux_2level_size50[13]->in[38] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[13]->in[39] density = 0, probability=0.*****
Vmux_2level_size50[13]->in[39] mux_2level_size50[13]->in[39] 0
+  0
***** Signal mux_2level_size50[13]->in[40] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[13]->in[40] mux_2level_size50[13]->in[40] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[13]->in[41] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[13]->in[41] mux_2level_size50[13]->in[41] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[13]->in[42] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[13]->in[42] mux_2level_size50[13]->in[42] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[13]->in[43] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[13]->in[43] mux_2level_size50[13]->in[43] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[13]->in[44] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[13]->in[44] mux_2level_size50[13]->in[44] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[13]->in[45] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[13]->in[45] mux_2level_size50[13]->in[45] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[13]->in[46] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[13]->in[46] mux_2level_size50[13]->in[46] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[13]->in[47] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[13]->in[47] mux_2level_size50[13]->in[47] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[13]->in[48] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[13]->in[48] mux_2level_size50[13]->in[48] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[13]->in[49] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[13]->in[49] mux_2level_size50[13]->in[49] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
Vgvdd_mux_2level_size50[13] gvdd_mux_2level_size50[13] 0 vsp
***** Measurements *****
***** Rise delay *****
.meas tran delay_rise_idle_mux50[13]_in[1]_crossbar trig v(mux_2level_size50[13]->in[0]) val='input_thres_pct_rise*vsp' rise=1 td='clock_period'
+          targ v(mux_2level_size50[13]->out) val='output_thres_pct_rise*vsp' rise=1 td='clock_period'
***** Fall delay *****
.meas tran delay_fall_idle_mux50[13]_in[1]_crossbar trig v(mux_2level_size50[13]->in[0]) val='input_thres_pct_fall*vsp' fall=1 td='clock_period'
+          targ v(mux_2level_size50[13]->out) val='output_thres_pct_fall*vsp' fall=1 td='clock_period'
***** Rise timing period *****
.meas start_rise_idle_mux50[13]_in[1]_crossbar when v(mux_2level_size50[13]->in[0])='slew_lower_thres_pct_rise*vsp' rise=1 td='clock_period'
.meas tran switch_rise_idle_mux50[13]_in[1]_crossbar trig v(mux_2level_size50[13]->in[0]) val='slew_lower_thres_pct_rise*vsp' rise=1 td='clock_period'
+          targ v(mux_2level_size50[13]->out) val='slew_upper_thres_pct_rise*vsp' rise=1 td='clock_period'
***** Fall timing period *****
.meas start_fall_idle_mux50[13]_in[1]_crossbar when v(mux_2level_size50[13]->in[0])='slew_lower_thres_pct_fall*vsp' fall=1 td='clock_period'
.meas tran switch_fall_idle_mux50[13]_in[1]_crossbar trig v(mux_2level_size50[13]->in[0]) val='slew_lower_thres_pct_fall*vsp' fall=1 td='clock_period'
+          targ v(mux_2level_size50[13]->out) val='slew_upper_thres_pct_fall*vsp' fall=1 td='clock_period'
***** Leakage Power Measurement *****
.meas tran mux_2level_size50[13]_leakage_power avg p(Vgvdd_mux_2level_size50[13]) from=0 to='clock_period'
.meas tran leakage_idle_mux50[13]_in[1]_crossbar param='mux_2level_size50[13]_leakage_power'
***** Dynamic Power Measurement *****
.meas tran mux_2level_size50[13]_dynamic_power avg p(Vgvdd_mux_2level_size50[13]) from='clock_period' to='6*clock_period'
.meas tran mux_2level_size50[13]_energy_per_cycle param='mux_2level_size50[13]_dynamic_power*clock_period'
.meas tran dynamic_power_idle_mux50[13]_in[1]_crossbar  param='mux_2level_size50[13]_dynamic_power'
.meas tran energy_per_cycle_idle_mux50[13]_in[1]_crossbar  param='dynamic_power_idle_mux50[13]_in[1]_crossbar*clock_period'
.meas tran dynamic_rise_idle_mux50[13]_in[1]_crossbar avg p(Vgvdd_mux_2level_size50[13]) from='start_rise_idle_mux50[13]_in[1]_crossbar' to='start_rise_idle_mux50[13]_in[1]_crossbar+switch_rise_idle_mux50[13]_in[1]_crossbar'
.meas tran dynamic_fall_idle_mux50[13]_in[1]_crossbar avg p(Vgvdd_mux_2level_size50[13]) from='start_fall_idle_mux50[13]_in[1]_crossbar' to='start_fall_idle_mux50[13]_in[1]_crossbar+switch_fall_idle_mux50[13]_in[1]_crossbar'
.meas tran sum_leakage_power_mux[0to13]
+          param='sum_leakage_power_mux[0to12]+leakage_idle_mux50[13]_in[1]_crossbar'
.meas tran sum_energy_per_cycle_mux[0to13]
+          param='sum_energy_per_cycle_mux[0to12]+energy_per_cycle_idle_mux50[13]_in[1]_crossbar'
Xload_inv[13]_no0 mux_2level_size50[13]->out mux_2level_size50[13]->out_out[0] gvdd_load 0 inv size=5
.meas tran sum_leakage_power_pb_mux[0to13]
+          param='sum_leakage_power_pb_mux[0to12]+leakage_idle_mux50[13]_in[1]_crossbar'
.meas tran sum_energy_per_cycle_pb_mux[0to13]
+          param='sum_energy_per_cycle_pb_mux[0to12]+energy_per_cycle_idle_mux50[13]_in[1]_crossbar'
Xmux_2level_size50[14] mux_2level_size50[14]->in[0] mux_2level_size50[14]->in[1] mux_2level_size50[14]->in[2] mux_2level_size50[14]->in[3] mux_2level_size50[14]->in[4] mux_2level_size50[14]->in[5] mux_2level_size50[14]->in[6] mux_2level_size50[14]->in[7] mux_2level_size50[14]->in[8] mux_2level_size50[14]->in[9] mux_2level_size50[14]->in[10] mux_2level_size50[14]->in[11] mux_2level_size50[14]->in[12] mux_2level_size50[14]->in[13] mux_2level_size50[14]->in[14] mux_2level_size50[14]->in[15] mux_2level_size50[14]->in[16] mux_2level_size50[14]->in[17] mux_2level_size50[14]->in[18] mux_2level_size50[14]->in[19] mux_2level_size50[14]->in[20] mux_2level_size50[14]->in[21] mux_2level_size50[14]->in[22] mux_2level_size50[14]->in[23] mux_2level_size50[14]->in[24] mux_2level_size50[14]->in[25] mux_2level_size50[14]->in[26] mux_2level_size50[14]->in[27] mux_2level_size50[14]->in[28] mux_2level_size50[14]->in[29] mux_2level_size50[14]->in[30] mux_2level_size50[14]->in[31] mux_2level_size50[14]->in[32] mux_2level_size50[14]->in[33] mux_2level_size50[14]->in[34] mux_2level_size50[14]->in[35] mux_2level_size50[14]->in[36] mux_2level_size50[14]->in[37] mux_2level_size50[14]->in[38] mux_2level_size50[14]->in[39] mux_2level_size50[14]->in[40] mux_2level_size50[14]->in[41] mux_2level_size50[14]->in[42] mux_2level_size50[14]->in[43] mux_2level_size50[14]->in[44] mux_2level_size50[14]->in[45] mux_2level_size50[14]->in[46] mux_2level_size50[14]->in[47] mux_2level_size50[14]->in[48] mux_2level_size50[14]->in[49] mux_2level_size50[14]->out sram[224]->outb sram[224]->out sram[225]->out sram[225]->outb sram[226]->out sram[226]->outb sram[227]->out sram[227]->outb sram[228]->out sram[228]->outb sram[229]->out sram[229]->outb sram[230]->out sram[230]->outb sram[231]->out sram[231]->outb sram[232]->outb sram[232]->out sram[233]->out sram[233]->outb sram[234]->out sram[234]->outb sram[235]->out sram[235]->outb sram[236]->out sram[236]->outb sram[237]->out sram[237]->outb sram[238]->out sram[238]->outb sram[239]->out sram[239]->outb gvdd_mux_2level_size50[14] 0 mux_2level_size50
***** SRAM bits for MUX[14], level=2, select_path_id=0. *****
*****1000000010000000*****
Xsram[224] sram->in sram[224]->out sram[224]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[224]->out) 0
.nodeset V(sram[224]->outb) vsp
Xsram[225] sram->in sram[225]->out sram[225]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[225]->out) 0
.nodeset V(sram[225]->outb) vsp
Xsram[226] sram->in sram[226]->out sram[226]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[226]->out) 0
.nodeset V(sram[226]->outb) vsp
Xsram[227] sram->in sram[227]->out sram[227]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[227]->out) 0
.nodeset V(sram[227]->outb) vsp
Xsram[228] sram->in sram[228]->out sram[228]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[228]->out) 0
.nodeset V(sram[228]->outb) vsp
Xsram[229] sram->in sram[229]->out sram[229]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[229]->out) 0
.nodeset V(sram[229]->outb) vsp
Xsram[230] sram->in sram[230]->out sram[230]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[230]->out) 0
.nodeset V(sram[230]->outb) vsp
Xsram[231] sram->in sram[231]->out sram[231]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[231]->out) 0
.nodeset V(sram[231]->outb) vsp
Xsram[232] sram->in sram[232]->out sram[232]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[232]->out) 0
.nodeset V(sram[232]->outb) vsp
Xsram[233] sram->in sram[233]->out sram[233]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[233]->out) 0
.nodeset V(sram[233]->outb) vsp
Xsram[234] sram->in sram[234]->out sram[234]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[234]->out) 0
.nodeset V(sram[234]->outb) vsp
Xsram[235] sram->in sram[235]->out sram[235]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[235]->out) 0
.nodeset V(sram[235]->outb) vsp
Xsram[236] sram->in sram[236]->out sram[236]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[236]->out) 0
.nodeset V(sram[236]->outb) vsp
Xsram[237] sram->in sram[237]->out sram[237]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[237]->out) 0
.nodeset V(sram[237]->outb) vsp
Xsram[238] sram->in sram[238]->out sram[238]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[238]->out) 0
.nodeset V(sram[238]->outb) vsp
Xsram[239] sram->in sram[239]->out sram[239]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[239]->out) 0
.nodeset V(sram[239]->outb) vsp
***** Signal mux_2level_size50[14]->in[0] density = 0, probability=0.*****
Vmux_2level_size50[14]->in[0] mux_2level_size50[14]->in[0] 0
+  0
***** Signal mux_2level_size50[14]->in[1] density = 0, probability=0.*****
Vmux_2level_size50[14]->in[1] mux_2level_size50[14]->in[1] 0
+  0
***** Signal mux_2level_size50[14]->in[2] density = 0, probability=0.*****
Vmux_2level_size50[14]->in[2] mux_2level_size50[14]->in[2] 0
+  0
***** Signal mux_2level_size50[14]->in[3] density = 0, probability=0.*****
Vmux_2level_size50[14]->in[3] mux_2level_size50[14]->in[3] 0
+  0
***** Signal mux_2level_size50[14]->in[4] density = 0, probability=0.*****
Vmux_2level_size50[14]->in[4] mux_2level_size50[14]->in[4] 0
+  0
***** Signal mux_2level_size50[14]->in[5] density = 0, probability=0.*****
Vmux_2level_size50[14]->in[5] mux_2level_size50[14]->in[5] 0
+  0
***** Signal mux_2level_size50[14]->in[6] density = 0, probability=0.*****
Vmux_2level_size50[14]->in[6] mux_2level_size50[14]->in[6] 0
+  0
***** Signal mux_2level_size50[14]->in[7] density = 0, probability=0.*****
Vmux_2level_size50[14]->in[7] mux_2level_size50[14]->in[7] 0
+  0
***** Signal mux_2level_size50[14]->in[8] density = 0, probability=0.*****
Vmux_2level_size50[14]->in[8] mux_2level_size50[14]->in[8] 0
+  0
***** Signal mux_2level_size50[14]->in[9] density = 0, probability=0.*****
Vmux_2level_size50[14]->in[9] mux_2level_size50[14]->in[9] 0
+  0
***** Signal mux_2level_size50[14]->in[10] density = 0, probability=0.*****
Vmux_2level_size50[14]->in[10] mux_2level_size50[14]->in[10] 0
+  0
***** Signal mux_2level_size50[14]->in[11] density = 0, probability=0.*****
Vmux_2level_size50[14]->in[11] mux_2level_size50[14]->in[11] 0
+  0
***** Signal mux_2level_size50[14]->in[12] density = 0, probability=0.*****
Vmux_2level_size50[14]->in[12] mux_2level_size50[14]->in[12] 0
+  0
***** Signal mux_2level_size50[14]->in[13] density = 0, probability=0.*****
Vmux_2level_size50[14]->in[13] mux_2level_size50[14]->in[13] 0
+  0
***** Signal mux_2level_size50[14]->in[14] density = 0, probability=0.*****
Vmux_2level_size50[14]->in[14] mux_2level_size50[14]->in[14] 0
+  0
***** Signal mux_2level_size50[14]->in[15] density = 0, probability=0.*****
Vmux_2level_size50[14]->in[15] mux_2level_size50[14]->in[15] 0
+  0
***** Signal mux_2level_size50[14]->in[16] density = 0, probability=0.*****
Vmux_2level_size50[14]->in[16] mux_2level_size50[14]->in[16] 0
+  0
***** Signal mux_2level_size50[14]->in[17] density = 0, probability=0.*****
Vmux_2level_size50[14]->in[17] mux_2level_size50[14]->in[17] 0
+  0
***** Signal mux_2level_size50[14]->in[18] density = 0, probability=0.*****
Vmux_2level_size50[14]->in[18] mux_2level_size50[14]->in[18] 0
+  0
***** Signal mux_2level_size50[14]->in[19] density = 0, probability=0.*****
Vmux_2level_size50[14]->in[19] mux_2level_size50[14]->in[19] 0
+  0
***** Signal mux_2level_size50[14]->in[20] density = 0, probability=0.*****
Vmux_2level_size50[14]->in[20] mux_2level_size50[14]->in[20] 0
+  0
***** Signal mux_2level_size50[14]->in[21] density = 0, probability=0.*****
Vmux_2level_size50[14]->in[21] mux_2level_size50[14]->in[21] 0
+  0
***** Signal mux_2level_size50[14]->in[22] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[14]->in[22] mux_2level_size50[14]->in[22] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[14]->in[23] density = 0, probability=0.*****
Vmux_2level_size50[14]->in[23] mux_2level_size50[14]->in[23] 0
+  0
***** Signal mux_2level_size50[14]->in[24] density = 0, probability=0.*****
Vmux_2level_size50[14]->in[24] mux_2level_size50[14]->in[24] 0
+  0
***** Signal mux_2level_size50[14]->in[25] density = 0, probability=0.*****
Vmux_2level_size50[14]->in[25] mux_2level_size50[14]->in[25] 0
+  0
***** Signal mux_2level_size50[14]->in[26] density = 0, probability=0.*****
Vmux_2level_size50[14]->in[26] mux_2level_size50[14]->in[26] 0
+  0
***** Signal mux_2level_size50[14]->in[27] density = 0, probability=0.*****
Vmux_2level_size50[14]->in[27] mux_2level_size50[14]->in[27] 0
+  0
***** Signal mux_2level_size50[14]->in[28] density = 0, probability=0.*****
Vmux_2level_size50[14]->in[28] mux_2level_size50[14]->in[28] 0
+  0
***** Signal mux_2level_size50[14]->in[29] density = 0, probability=0.*****
Vmux_2level_size50[14]->in[29] mux_2level_size50[14]->in[29] 0
+  0
***** Signal mux_2level_size50[14]->in[30] density = 0, probability=0.*****
Vmux_2level_size50[14]->in[30] mux_2level_size50[14]->in[30] 0
+  0
***** Signal mux_2level_size50[14]->in[31] density = 0, probability=0.*****
Vmux_2level_size50[14]->in[31] mux_2level_size50[14]->in[31] 0
+  0
***** Signal mux_2level_size50[14]->in[32] density = 0, probability=0.*****
Vmux_2level_size50[14]->in[32] mux_2level_size50[14]->in[32] 0
+  0
***** Signal mux_2level_size50[14]->in[33] density = 0, probability=0.*****
Vmux_2level_size50[14]->in[33] mux_2level_size50[14]->in[33] 0
+  0
***** Signal mux_2level_size50[14]->in[34] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[14]->in[34] mux_2level_size50[14]->in[34] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[14]->in[35] density = 0, probability=0.*****
Vmux_2level_size50[14]->in[35] mux_2level_size50[14]->in[35] 0
+  0
***** Signal mux_2level_size50[14]->in[36] density = 0, probability=0.*****
Vmux_2level_size50[14]->in[36] mux_2level_size50[14]->in[36] 0
+  0
***** Signal mux_2level_size50[14]->in[37] density = 0, probability=0.*****
Vmux_2level_size50[14]->in[37] mux_2level_size50[14]->in[37] 0
+  0
***** Signal mux_2level_size50[14]->in[38] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[14]->in[38] mux_2level_size50[14]->in[38] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[14]->in[39] density = 0, probability=0.*****
Vmux_2level_size50[14]->in[39] mux_2level_size50[14]->in[39] 0
+  0
***** Signal mux_2level_size50[14]->in[40] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[14]->in[40] mux_2level_size50[14]->in[40] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[14]->in[41] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[14]->in[41] mux_2level_size50[14]->in[41] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[14]->in[42] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[14]->in[42] mux_2level_size50[14]->in[42] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[14]->in[43] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[14]->in[43] mux_2level_size50[14]->in[43] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[14]->in[44] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[14]->in[44] mux_2level_size50[14]->in[44] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[14]->in[45] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[14]->in[45] mux_2level_size50[14]->in[45] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[14]->in[46] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[14]->in[46] mux_2level_size50[14]->in[46] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[14]->in[47] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[14]->in[47] mux_2level_size50[14]->in[47] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[14]->in[48] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[14]->in[48] mux_2level_size50[14]->in[48] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[14]->in[49] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[14]->in[49] mux_2level_size50[14]->in[49] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
Vgvdd_mux_2level_size50[14] gvdd_mux_2level_size50[14] 0 vsp
***** Measurements *****
***** Rise delay *****
.meas tran delay_rise_idle_mux50[14]_in[2]_crossbar trig v(mux_2level_size50[14]->in[0]) val='input_thres_pct_rise*vsp' rise=1 td='clock_period'
+          targ v(mux_2level_size50[14]->out) val='output_thres_pct_rise*vsp' rise=1 td='clock_period'
***** Fall delay *****
.meas tran delay_fall_idle_mux50[14]_in[2]_crossbar trig v(mux_2level_size50[14]->in[0]) val='input_thres_pct_fall*vsp' fall=1 td='clock_period'
+          targ v(mux_2level_size50[14]->out) val='output_thres_pct_fall*vsp' fall=1 td='clock_period'
***** Rise timing period *****
.meas start_rise_idle_mux50[14]_in[2]_crossbar when v(mux_2level_size50[14]->in[0])='slew_lower_thres_pct_rise*vsp' rise=1 td='clock_period'
.meas tran switch_rise_idle_mux50[14]_in[2]_crossbar trig v(mux_2level_size50[14]->in[0]) val='slew_lower_thres_pct_rise*vsp' rise=1 td='clock_period'
+          targ v(mux_2level_size50[14]->out) val='slew_upper_thres_pct_rise*vsp' rise=1 td='clock_period'
***** Fall timing period *****
.meas start_fall_idle_mux50[14]_in[2]_crossbar when v(mux_2level_size50[14]->in[0])='slew_lower_thres_pct_fall*vsp' fall=1 td='clock_period'
.meas tran switch_fall_idle_mux50[14]_in[2]_crossbar trig v(mux_2level_size50[14]->in[0]) val='slew_lower_thres_pct_fall*vsp' fall=1 td='clock_period'
+          targ v(mux_2level_size50[14]->out) val='slew_upper_thres_pct_fall*vsp' fall=1 td='clock_period'
***** Leakage Power Measurement *****
.meas tran mux_2level_size50[14]_leakage_power avg p(Vgvdd_mux_2level_size50[14]) from=0 to='clock_period'
.meas tran leakage_idle_mux50[14]_in[2]_crossbar param='mux_2level_size50[14]_leakage_power'
***** Dynamic Power Measurement *****
.meas tran mux_2level_size50[14]_dynamic_power avg p(Vgvdd_mux_2level_size50[14]) from='clock_period' to='6*clock_period'
.meas tran mux_2level_size50[14]_energy_per_cycle param='mux_2level_size50[14]_dynamic_power*clock_period'
.meas tran dynamic_power_idle_mux50[14]_in[2]_crossbar  param='mux_2level_size50[14]_dynamic_power'
.meas tran energy_per_cycle_idle_mux50[14]_in[2]_crossbar  param='dynamic_power_idle_mux50[14]_in[2]_crossbar*clock_period'
.meas tran dynamic_rise_idle_mux50[14]_in[2]_crossbar avg p(Vgvdd_mux_2level_size50[14]) from='start_rise_idle_mux50[14]_in[2]_crossbar' to='start_rise_idle_mux50[14]_in[2]_crossbar+switch_rise_idle_mux50[14]_in[2]_crossbar'
.meas tran dynamic_fall_idle_mux50[14]_in[2]_crossbar avg p(Vgvdd_mux_2level_size50[14]) from='start_fall_idle_mux50[14]_in[2]_crossbar' to='start_fall_idle_mux50[14]_in[2]_crossbar+switch_fall_idle_mux50[14]_in[2]_crossbar'
.meas tran sum_leakage_power_mux[0to14]
+          param='sum_leakage_power_mux[0to13]+leakage_idle_mux50[14]_in[2]_crossbar'
.meas tran sum_energy_per_cycle_mux[0to14]
+          param='sum_energy_per_cycle_mux[0to13]+energy_per_cycle_idle_mux50[14]_in[2]_crossbar'
Xload_inv[14]_no0 mux_2level_size50[14]->out mux_2level_size50[14]->out_out[0] gvdd_load 0 inv size=5
.meas tran sum_leakage_power_pb_mux[0to14]
+          param='sum_leakage_power_pb_mux[0to13]+leakage_idle_mux50[14]_in[2]_crossbar'
.meas tran sum_energy_per_cycle_pb_mux[0to14]
+          param='sum_energy_per_cycle_pb_mux[0to13]+energy_per_cycle_idle_mux50[14]_in[2]_crossbar'
Xmux_2level_size50[15] mux_2level_size50[15]->in[0] mux_2level_size50[15]->in[1] mux_2level_size50[15]->in[2] mux_2level_size50[15]->in[3] mux_2level_size50[15]->in[4] mux_2level_size50[15]->in[5] mux_2level_size50[15]->in[6] mux_2level_size50[15]->in[7] mux_2level_size50[15]->in[8] mux_2level_size50[15]->in[9] mux_2level_size50[15]->in[10] mux_2level_size50[15]->in[11] mux_2level_size50[15]->in[12] mux_2level_size50[15]->in[13] mux_2level_size50[15]->in[14] mux_2level_size50[15]->in[15] mux_2level_size50[15]->in[16] mux_2level_size50[15]->in[17] mux_2level_size50[15]->in[18] mux_2level_size50[15]->in[19] mux_2level_size50[15]->in[20] mux_2level_size50[15]->in[21] mux_2level_size50[15]->in[22] mux_2level_size50[15]->in[23] mux_2level_size50[15]->in[24] mux_2level_size50[15]->in[25] mux_2level_size50[15]->in[26] mux_2level_size50[15]->in[27] mux_2level_size50[15]->in[28] mux_2level_size50[15]->in[29] mux_2level_size50[15]->in[30] mux_2level_size50[15]->in[31] mux_2level_size50[15]->in[32] mux_2level_size50[15]->in[33] mux_2level_size50[15]->in[34] mux_2level_size50[15]->in[35] mux_2level_size50[15]->in[36] mux_2level_size50[15]->in[37] mux_2level_size50[15]->in[38] mux_2level_size50[15]->in[39] mux_2level_size50[15]->in[40] mux_2level_size50[15]->in[41] mux_2level_size50[15]->in[42] mux_2level_size50[15]->in[43] mux_2level_size50[15]->in[44] mux_2level_size50[15]->in[45] mux_2level_size50[15]->in[46] mux_2level_size50[15]->in[47] mux_2level_size50[15]->in[48] mux_2level_size50[15]->in[49] mux_2level_size50[15]->out sram[240]->outb sram[240]->out sram[241]->out sram[241]->outb sram[242]->out sram[242]->outb sram[243]->out sram[243]->outb sram[244]->out sram[244]->outb sram[245]->out sram[245]->outb sram[246]->out sram[246]->outb sram[247]->out sram[247]->outb sram[248]->outb sram[248]->out sram[249]->out sram[249]->outb sram[250]->out sram[250]->outb sram[251]->out sram[251]->outb sram[252]->out sram[252]->outb sram[253]->out sram[253]->outb sram[254]->out sram[254]->outb sram[255]->out sram[255]->outb gvdd_mux_2level_size50[15] 0 mux_2level_size50
***** SRAM bits for MUX[15], level=2, select_path_id=0. *****
*****1000000010000000*****
Xsram[240] sram->in sram[240]->out sram[240]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[240]->out) 0
.nodeset V(sram[240]->outb) vsp
Xsram[241] sram->in sram[241]->out sram[241]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[241]->out) 0
.nodeset V(sram[241]->outb) vsp
Xsram[242] sram->in sram[242]->out sram[242]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[242]->out) 0
.nodeset V(sram[242]->outb) vsp
Xsram[243] sram->in sram[243]->out sram[243]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[243]->out) 0
.nodeset V(sram[243]->outb) vsp
Xsram[244] sram->in sram[244]->out sram[244]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[244]->out) 0
.nodeset V(sram[244]->outb) vsp
Xsram[245] sram->in sram[245]->out sram[245]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[245]->out) 0
.nodeset V(sram[245]->outb) vsp
Xsram[246] sram->in sram[246]->out sram[246]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[246]->out) 0
.nodeset V(sram[246]->outb) vsp
Xsram[247] sram->in sram[247]->out sram[247]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[247]->out) 0
.nodeset V(sram[247]->outb) vsp
Xsram[248] sram->in sram[248]->out sram[248]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[248]->out) 0
.nodeset V(sram[248]->outb) vsp
Xsram[249] sram->in sram[249]->out sram[249]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[249]->out) 0
.nodeset V(sram[249]->outb) vsp
Xsram[250] sram->in sram[250]->out sram[250]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[250]->out) 0
.nodeset V(sram[250]->outb) vsp
Xsram[251] sram->in sram[251]->out sram[251]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[251]->out) 0
.nodeset V(sram[251]->outb) vsp
Xsram[252] sram->in sram[252]->out sram[252]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[252]->out) 0
.nodeset V(sram[252]->outb) vsp
Xsram[253] sram->in sram[253]->out sram[253]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[253]->out) 0
.nodeset V(sram[253]->outb) vsp
Xsram[254] sram->in sram[254]->out sram[254]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[254]->out) 0
.nodeset V(sram[254]->outb) vsp
Xsram[255] sram->in sram[255]->out sram[255]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[255]->out) 0
.nodeset V(sram[255]->outb) vsp
***** Signal mux_2level_size50[15]->in[0] density = 0, probability=0.*****
Vmux_2level_size50[15]->in[0] mux_2level_size50[15]->in[0] 0
+  0
***** Signal mux_2level_size50[15]->in[1] density = 0, probability=0.*****
Vmux_2level_size50[15]->in[1] mux_2level_size50[15]->in[1] 0
+  0
***** Signal mux_2level_size50[15]->in[2] density = 0, probability=0.*****
Vmux_2level_size50[15]->in[2] mux_2level_size50[15]->in[2] 0
+  0
***** Signal mux_2level_size50[15]->in[3] density = 0, probability=0.*****
Vmux_2level_size50[15]->in[3] mux_2level_size50[15]->in[3] 0
+  0
***** Signal mux_2level_size50[15]->in[4] density = 0, probability=0.*****
Vmux_2level_size50[15]->in[4] mux_2level_size50[15]->in[4] 0
+  0
***** Signal mux_2level_size50[15]->in[5] density = 0, probability=0.*****
Vmux_2level_size50[15]->in[5] mux_2level_size50[15]->in[5] 0
+  0
***** Signal mux_2level_size50[15]->in[6] density = 0, probability=0.*****
Vmux_2level_size50[15]->in[6] mux_2level_size50[15]->in[6] 0
+  0
***** Signal mux_2level_size50[15]->in[7] density = 0, probability=0.*****
Vmux_2level_size50[15]->in[7] mux_2level_size50[15]->in[7] 0
+  0
***** Signal mux_2level_size50[15]->in[8] density = 0, probability=0.*****
Vmux_2level_size50[15]->in[8] mux_2level_size50[15]->in[8] 0
+  0
***** Signal mux_2level_size50[15]->in[9] density = 0, probability=0.*****
Vmux_2level_size50[15]->in[9] mux_2level_size50[15]->in[9] 0
+  0
***** Signal mux_2level_size50[15]->in[10] density = 0, probability=0.*****
Vmux_2level_size50[15]->in[10] mux_2level_size50[15]->in[10] 0
+  0
***** Signal mux_2level_size50[15]->in[11] density = 0, probability=0.*****
Vmux_2level_size50[15]->in[11] mux_2level_size50[15]->in[11] 0
+  0
***** Signal mux_2level_size50[15]->in[12] density = 0, probability=0.*****
Vmux_2level_size50[15]->in[12] mux_2level_size50[15]->in[12] 0
+  0
***** Signal mux_2level_size50[15]->in[13] density = 0, probability=0.*****
Vmux_2level_size50[15]->in[13] mux_2level_size50[15]->in[13] 0
+  0
***** Signal mux_2level_size50[15]->in[14] density = 0, probability=0.*****
Vmux_2level_size50[15]->in[14] mux_2level_size50[15]->in[14] 0
+  0
***** Signal mux_2level_size50[15]->in[15] density = 0, probability=0.*****
Vmux_2level_size50[15]->in[15] mux_2level_size50[15]->in[15] 0
+  0
***** Signal mux_2level_size50[15]->in[16] density = 0, probability=0.*****
Vmux_2level_size50[15]->in[16] mux_2level_size50[15]->in[16] 0
+  0
***** Signal mux_2level_size50[15]->in[17] density = 0, probability=0.*****
Vmux_2level_size50[15]->in[17] mux_2level_size50[15]->in[17] 0
+  0
***** Signal mux_2level_size50[15]->in[18] density = 0, probability=0.*****
Vmux_2level_size50[15]->in[18] mux_2level_size50[15]->in[18] 0
+  0
***** Signal mux_2level_size50[15]->in[19] density = 0, probability=0.*****
Vmux_2level_size50[15]->in[19] mux_2level_size50[15]->in[19] 0
+  0
***** Signal mux_2level_size50[15]->in[20] density = 0, probability=0.*****
Vmux_2level_size50[15]->in[20] mux_2level_size50[15]->in[20] 0
+  0
***** Signal mux_2level_size50[15]->in[21] density = 0, probability=0.*****
Vmux_2level_size50[15]->in[21] mux_2level_size50[15]->in[21] 0
+  0
***** Signal mux_2level_size50[15]->in[22] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[15]->in[22] mux_2level_size50[15]->in[22] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[15]->in[23] density = 0, probability=0.*****
Vmux_2level_size50[15]->in[23] mux_2level_size50[15]->in[23] 0
+  0
***** Signal mux_2level_size50[15]->in[24] density = 0, probability=0.*****
Vmux_2level_size50[15]->in[24] mux_2level_size50[15]->in[24] 0
+  0
***** Signal mux_2level_size50[15]->in[25] density = 0, probability=0.*****
Vmux_2level_size50[15]->in[25] mux_2level_size50[15]->in[25] 0
+  0
***** Signal mux_2level_size50[15]->in[26] density = 0, probability=0.*****
Vmux_2level_size50[15]->in[26] mux_2level_size50[15]->in[26] 0
+  0
***** Signal mux_2level_size50[15]->in[27] density = 0, probability=0.*****
Vmux_2level_size50[15]->in[27] mux_2level_size50[15]->in[27] 0
+  0
***** Signal mux_2level_size50[15]->in[28] density = 0, probability=0.*****
Vmux_2level_size50[15]->in[28] mux_2level_size50[15]->in[28] 0
+  0
***** Signal mux_2level_size50[15]->in[29] density = 0, probability=0.*****
Vmux_2level_size50[15]->in[29] mux_2level_size50[15]->in[29] 0
+  0
***** Signal mux_2level_size50[15]->in[30] density = 0, probability=0.*****
Vmux_2level_size50[15]->in[30] mux_2level_size50[15]->in[30] 0
+  0
***** Signal mux_2level_size50[15]->in[31] density = 0, probability=0.*****
Vmux_2level_size50[15]->in[31] mux_2level_size50[15]->in[31] 0
+  0
***** Signal mux_2level_size50[15]->in[32] density = 0, probability=0.*****
Vmux_2level_size50[15]->in[32] mux_2level_size50[15]->in[32] 0
+  0
***** Signal mux_2level_size50[15]->in[33] density = 0, probability=0.*****
Vmux_2level_size50[15]->in[33] mux_2level_size50[15]->in[33] 0
+  0
***** Signal mux_2level_size50[15]->in[34] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[15]->in[34] mux_2level_size50[15]->in[34] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[15]->in[35] density = 0, probability=0.*****
Vmux_2level_size50[15]->in[35] mux_2level_size50[15]->in[35] 0
+  0
***** Signal mux_2level_size50[15]->in[36] density = 0, probability=0.*****
Vmux_2level_size50[15]->in[36] mux_2level_size50[15]->in[36] 0
+  0
***** Signal mux_2level_size50[15]->in[37] density = 0, probability=0.*****
Vmux_2level_size50[15]->in[37] mux_2level_size50[15]->in[37] 0
+  0
***** Signal mux_2level_size50[15]->in[38] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[15]->in[38] mux_2level_size50[15]->in[38] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[15]->in[39] density = 0, probability=0.*****
Vmux_2level_size50[15]->in[39] mux_2level_size50[15]->in[39] 0
+  0
***** Signal mux_2level_size50[15]->in[40] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[15]->in[40] mux_2level_size50[15]->in[40] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[15]->in[41] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[15]->in[41] mux_2level_size50[15]->in[41] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[15]->in[42] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[15]->in[42] mux_2level_size50[15]->in[42] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[15]->in[43] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[15]->in[43] mux_2level_size50[15]->in[43] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[15]->in[44] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[15]->in[44] mux_2level_size50[15]->in[44] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[15]->in[45] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[15]->in[45] mux_2level_size50[15]->in[45] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[15]->in[46] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[15]->in[46] mux_2level_size50[15]->in[46] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[15]->in[47] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[15]->in[47] mux_2level_size50[15]->in[47] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[15]->in[48] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[15]->in[48] mux_2level_size50[15]->in[48] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[15]->in[49] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[15]->in[49] mux_2level_size50[15]->in[49] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
Vgvdd_mux_2level_size50[15] gvdd_mux_2level_size50[15] 0 vsp
***** Measurements *****
***** Rise delay *****
.meas tran delay_rise_idle_mux50[15]_in[3]_crossbar trig v(mux_2level_size50[15]->in[0]) val='input_thres_pct_rise*vsp' rise=1 td='clock_period'
+          targ v(mux_2level_size50[15]->out) val='output_thres_pct_rise*vsp' rise=1 td='clock_period'
***** Fall delay *****
.meas tran delay_fall_idle_mux50[15]_in[3]_crossbar trig v(mux_2level_size50[15]->in[0]) val='input_thres_pct_fall*vsp' fall=1 td='clock_period'
+          targ v(mux_2level_size50[15]->out) val='output_thres_pct_fall*vsp' fall=1 td='clock_period'
***** Rise timing period *****
.meas start_rise_idle_mux50[15]_in[3]_crossbar when v(mux_2level_size50[15]->in[0])='slew_lower_thres_pct_rise*vsp' rise=1 td='clock_period'
.meas tran switch_rise_idle_mux50[15]_in[3]_crossbar trig v(mux_2level_size50[15]->in[0]) val='slew_lower_thres_pct_rise*vsp' rise=1 td='clock_period'
+          targ v(mux_2level_size50[15]->out) val='slew_upper_thres_pct_rise*vsp' rise=1 td='clock_period'
***** Fall timing period *****
.meas start_fall_idle_mux50[15]_in[3]_crossbar when v(mux_2level_size50[15]->in[0])='slew_lower_thres_pct_fall*vsp' fall=1 td='clock_period'
.meas tran switch_fall_idle_mux50[15]_in[3]_crossbar trig v(mux_2level_size50[15]->in[0]) val='slew_lower_thres_pct_fall*vsp' fall=1 td='clock_period'
+          targ v(mux_2level_size50[15]->out) val='slew_upper_thres_pct_fall*vsp' fall=1 td='clock_period'
***** Leakage Power Measurement *****
.meas tran mux_2level_size50[15]_leakage_power avg p(Vgvdd_mux_2level_size50[15]) from=0 to='clock_period'
.meas tran leakage_idle_mux50[15]_in[3]_crossbar param='mux_2level_size50[15]_leakage_power'
***** Dynamic Power Measurement *****
.meas tran mux_2level_size50[15]_dynamic_power avg p(Vgvdd_mux_2level_size50[15]) from='clock_period' to='6*clock_period'
.meas tran mux_2level_size50[15]_energy_per_cycle param='mux_2level_size50[15]_dynamic_power*clock_period'
.meas tran dynamic_power_idle_mux50[15]_in[3]_crossbar  param='mux_2level_size50[15]_dynamic_power'
.meas tran energy_per_cycle_idle_mux50[15]_in[3]_crossbar  param='dynamic_power_idle_mux50[15]_in[3]_crossbar*clock_period'
.meas tran dynamic_rise_idle_mux50[15]_in[3]_crossbar avg p(Vgvdd_mux_2level_size50[15]) from='start_rise_idle_mux50[15]_in[3]_crossbar' to='start_rise_idle_mux50[15]_in[3]_crossbar+switch_rise_idle_mux50[15]_in[3]_crossbar'
.meas tran dynamic_fall_idle_mux50[15]_in[3]_crossbar avg p(Vgvdd_mux_2level_size50[15]) from='start_fall_idle_mux50[15]_in[3]_crossbar' to='start_fall_idle_mux50[15]_in[3]_crossbar+switch_fall_idle_mux50[15]_in[3]_crossbar'
.meas tran sum_leakage_power_mux[0to15]
+          param='sum_leakage_power_mux[0to14]+leakage_idle_mux50[15]_in[3]_crossbar'
.meas tran sum_energy_per_cycle_mux[0to15]
+          param='sum_energy_per_cycle_mux[0to14]+energy_per_cycle_idle_mux50[15]_in[3]_crossbar'
Xload_inv[15]_no0 mux_2level_size50[15]->out mux_2level_size50[15]->out_out[0] gvdd_load 0 inv size=5
.meas tran sum_leakage_power_pb_mux[0to15]
+          param='sum_leakage_power_pb_mux[0to14]+leakage_idle_mux50[15]_in[3]_crossbar'
.meas tran sum_energy_per_cycle_pb_mux[0to15]
+          param='sum_energy_per_cycle_pb_mux[0to14]+energy_per_cycle_idle_mux50[15]_in[3]_crossbar'
Xmux_2level_size50[16] mux_2level_size50[16]->in[0] mux_2level_size50[16]->in[1] mux_2level_size50[16]->in[2] mux_2level_size50[16]->in[3] mux_2level_size50[16]->in[4] mux_2level_size50[16]->in[5] mux_2level_size50[16]->in[6] mux_2level_size50[16]->in[7] mux_2level_size50[16]->in[8] mux_2level_size50[16]->in[9] mux_2level_size50[16]->in[10] mux_2level_size50[16]->in[11] mux_2level_size50[16]->in[12] mux_2level_size50[16]->in[13] mux_2level_size50[16]->in[14] mux_2level_size50[16]->in[15] mux_2level_size50[16]->in[16] mux_2level_size50[16]->in[17] mux_2level_size50[16]->in[18] mux_2level_size50[16]->in[19] mux_2level_size50[16]->in[20] mux_2level_size50[16]->in[21] mux_2level_size50[16]->in[22] mux_2level_size50[16]->in[23] mux_2level_size50[16]->in[24] mux_2level_size50[16]->in[25] mux_2level_size50[16]->in[26] mux_2level_size50[16]->in[27] mux_2level_size50[16]->in[28] mux_2level_size50[16]->in[29] mux_2level_size50[16]->in[30] mux_2level_size50[16]->in[31] mux_2level_size50[16]->in[32] mux_2level_size50[16]->in[33] mux_2level_size50[16]->in[34] mux_2level_size50[16]->in[35] mux_2level_size50[16]->in[36] mux_2level_size50[16]->in[37] mux_2level_size50[16]->in[38] mux_2level_size50[16]->in[39] mux_2level_size50[16]->in[40] mux_2level_size50[16]->in[41] mux_2level_size50[16]->in[42] mux_2level_size50[16]->in[43] mux_2level_size50[16]->in[44] mux_2level_size50[16]->in[45] mux_2level_size50[16]->in[46] mux_2level_size50[16]->in[47] mux_2level_size50[16]->in[48] mux_2level_size50[16]->in[49] mux_2level_size50[16]->out sram[256]->outb sram[256]->out sram[257]->out sram[257]->outb sram[258]->out sram[258]->outb sram[259]->out sram[259]->outb sram[260]->out sram[260]->outb sram[261]->out sram[261]->outb sram[262]->out sram[262]->outb sram[263]->out sram[263]->outb sram[264]->outb sram[264]->out sram[265]->out sram[265]->outb sram[266]->out sram[266]->outb sram[267]->out sram[267]->outb sram[268]->out sram[268]->outb sram[269]->out sram[269]->outb sram[270]->out sram[270]->outb sram[271]->out sram[271]->outb gvdd_mux_2level_size50[16] 0 mux_2level_size50
***** SRAM bits for MUX[16], level=2, select_path_id=0. *****
*****1000000010000000*****
Xsram[256] sram->in sram[256]->out sram[256]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[256]->out) 0
.nodeset V(sram[256]->outb) vsp
Xsram[257] sram->in sram[257]->out sram[257]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[257]->out) 0
.nodeset V(sram[257]->outb) vsp
Xsram[258] sram->in sram[258]->out sram[258]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[258]->out) 0
.nodeset V(sram[258]->outb) vsp
Xsram[259] sram->in sram[259]->out sram[259]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[259]->out) 0
.nodeset V(sram[259]->outb) vsp
Xsram[260] sram->in sram[260]->out sram[260]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[260]->out) 0
.nodeset V(sram[260]->outb) vsp
Xsram[261] sram->in sram[261]->out sram[261]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[261]->out) 0
.nodeset V(sram[261]->outb) vsp
Xsram[262] sram->in sram[262]->out sram[262]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[262]->out) 0
.nodeset V(sram[262]->outb) vsp
Xsram[263] sram->in sram[263]->out sram[263]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[263]->out) 0
.nodeset V(sram[263]->outb) vsp
Xsram[264] sram->in sram[264]->out sram[264]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[264]->out) 0
.nodeset V(sram[264]->outb) vsp
Xsram[265] sram->in sram[265]->out sram[265]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[265]->out) 0
.nodeset V(sram[265]->outb) vsp
Xsram[266] sram->in sram[266]->out sram[266]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[266]->out) 0
.nodeset V(sram[266]->outb) vsp
Xsram[267] sram->in sram[267]->out sram[267]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[267]->out) 0
.nodeset V(sram[267]->outb) vsp
Xsram[268] sram->in sram[268]->out sram[268]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[268]->out) 0
.nodeset V(sram[268]->outb) vsp
Xsram[269] sram->in sram[269]->out sram[269]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[269]->out) 0
.nodeset V(sram[269]->outb) vsp
Xsram[270] sram->in sram[270]->out sram[270]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[270]->out) 0
.nodeset V(sram[270]->outb) vsp
Xsram[271] sram->in sram[271]->out sram[271]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[271]->out) 0
.nodeset V(sram[271]->outb) vsp
***** Signal mux_2level_size50[16]->in[0] density = 0, probability=0.*****
Vmux_2level_size50[16]->in[0] mux_2level_size50[16]->in[0] 0
+  0
***** Signal mux_2level_size50[16]->in[1] density = 0, probability=0.*****
Vmux_2level_size50[16]->in[1] mux_2level_size50[16]->in[1] 0
+  0
***** Signal mux_2level_size50[16]->in[2] density = 0, probability=0.*****
Vmux_2level_size50[16]->in[2] mux_2level_size50[16]->in[2] 0
+  0
***** Signal mux_2level_size50[16]->in[3] density = 0, probability=0.*****
Vmux_2level_size50[16]->in[3] mux_2level_size50[16]->in[3] 0
+  0
***** Signal mux_2level_size50[16]->in[4] density = 0, probability=0.*****
Vmux_2level_size50[16]->in[4] mux_2level_size50[16]->in[4] 0
+  0
***** Signal mux_2level_size50[16]->in[5] density = 0, probability=0.*****
Vmux_2level_size50[16]->in[5] mux_2level_size50[16]->in[5] 0
+  0
***** Signal mux_2level_size50[16]->in[6] density = 0, probability=0.*****
Vmux_2level_size50[16]->in[6] mux_2level_size50[16]->in[6] 0
+  0
***** Signal mux_2level_size50[16]->in[7] density = 0, probability=0.*****
Vmux_2level_size50[16]->in[7] mux_2level_size50[16]->in[7] 0
+  0
***** Signal mux_2level_size50[16]->in[8] density = 0, probability=0.*****
Vmux_2level_size50[16]->in[8] mux_2level_size50[16]->in[8] 0
+  0
***** Signal mux_2level_size50[16]->in[9] density = 0, probability=0.*****
Vmux_2level_size50[16]->in[9] mux_2level_size50[16]->in[9] 0
+  0
***** Signal mux_2level_size50[16]->in[10] density = 0, probability=0.*****
Vmux_2level_size50[16]->in[10] mux_2level_size50[16]->in[10] 0
+  0
***** Signal mux_2level_size50[16]->in[11] density = 0, probability=0.*****
Vmux_2level_size50[16]->in[11] mux_2level_size50[16]->in[11] 0
+  0
***** Signal mux_2level_size50[16]->in[12] density = 0, probability=0.*****
Vmux_2level_size50[16]->in[12] mux_2level_size50[16]->in[12] 0
+  0
***** Signal mux_2level_size50[16]->in[13] density = 0, probability=0.*****
Vmux_2level_size50[16]->in[13] mux_2level_size50[16]->in[13] 0
+  0
***** Signal mux_2level_size50[16]->in[14] density = 0, probability=0.*****
Vmux_2level_size50[16]->in[14] mux_2level_size50[16]->in[14] 0
+  0
***** Signal mux_2level_size50[16]->in[15] density = 0, probability=0.*****
Vmux_2level_size50[16]->in[15] mux_2level_size50[16]->in[15] 0
+  0
***** Signal mux_2level_size50[16]->in[16] density = 0, probability=0.*****
Vmux_2level_size50[16]->in[16] mux_2level_size50[16]->in[16] 0
+  0
***** Signal mux_2level_size50[16]->in[17] density = 0, probability=0.*****
Vmux_2level_size50[16]->in[17] mux_2level_size50[16]->in[17] 0
+  0
***** Signal mux_2level_size50[16]->in[18] density = 0, probability=0.*****
Vmux_2level_size50[16]->in[18] mux_2level_size50[16]->in[18] 0
+  0
***** Signal mux_2level_size50[16]->in[19] density = 0, probability=0.*****
Vmux_2level_size50[16]->in[19] mux_2level_size50[16]->in[19] 0
+  0
***** Signal mux_2level_size50[16]->in[20] density = 0, probability=0.*****
Vmux_2level_size50[16]->in[20] mux_2level_size50[16]->in[20] 0
+  0
***** Signal mux_2level_size50[16]->in[21] density = 0, probability=0.*****
Vmux_2level_size50[16]->in[21] mux_2level_size50[16]->in[21] 0
+  0
***** Signal mux_2level_size50[16]->in[22] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[16]->in[22] mux_2level_size50[16]->in[22] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[16]->in[23] density = 0, probability=0.*****
Vmux_2level_size50[16]->in[23] mux_2level_size50[16]->in[23] 0
+  0
***** Signal mux_2level_size50[16]->in[24] density = 0, probability=0.*****
Vmux_2level_size50[16]->in[24] mux_2level_size50[16]->in[24] 0
+  0
***** Signal mux_2level_size50[16]->in[25] density = 0, probability=0.*****
Vmux_2level_size50[16]->in[25] mux_2level_size50[16]->in[25] 0
+  0
***** Signal mux_2level_size50[16]->in[26] density = 0, probability=0.*****
Vmux_2level_size50[16]->in[26] mux_2level_size50[16]->in[26] 0
+  0
***** Signal mux_2level_size50[16]->in[27] density = 0, probability=0.*****
Vmux_2level_size50[16]->in[27] mux_2level_size50[16]->in[27] 0
+  0
***** Signal mux_2level_size50[16]->in[28] density = 0, probability=0.*****
Vmux_2level_size50[16]->in[28] mux_2level_size50[16]->in[28] 0
+  0
***** Signal mux_2level_size50[16]->in[29] density = 0, probability=0.*****
Vmux_2level_size50[16]->in[29] mux_2level_size50[16]->in[29] 0
+  0
***** Signal mux_2level_size50[16]->in[30] density = 0, probability=0.*****
Vmux_2level_size50[16]->in[30] mux_2level_size50[16]->in[30] 0
+  0
***** Signal mux_2level_size50[16]->in[31] density = 0, probability=0.*****
Vmux_2level_size50[16]->in[31] mux_2level_size50[16]->in[31] 0
+  0
***** Signal mux_2level_size50[16]->in[32] density = 0, probability=0.*****
Vmux_2level_size50[16]->in[32] mux_2level_size50[16]->in[32] 0
+  0
***** Signal mux_2level_size50[16]->in[33] density = 0, probability=0.*****
Vmux_2level_size50[16]->in[33] mux_2level_size50[16]->in[33] 0
+  0
***** Signal mux_2level_size50[16]->in[34] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[16]->in[34] mux_2level_size50[16]->in[34] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[16]->in[35] density = 0, probability=0.*****
Vmux_2level_size50[16]->in[35] mux_2level_size50[16]->in[35] 0
+  0
***** Signal mux_2level_size50[16]->in[36] density = 0, probability=0.*****
Vmux_2level_size50[16]->in[36] mux_2level_size50[16]->in[36] 0
+  0
***** Signal mux_2level_size50[16]->in[37] density = 0, probability=0.*****
Vmux_2level_size50[16]->in[37] mux_2level_size50[16]->in[37] 0
+  0
***** Signal mux_2level_size50[16]->in[38] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[16]->in[38] mux_2level_size50[16]->in[38] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[16]->in[39] density = 0, probability=0.*****
Vmux_2level_size50[16]->in[39] mux_2level_size50[16]->in[39] 0
+  0
***** Signal mux_2level_size50[16]->in[40] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[16]->in[40] mux_2level_size50[16]->in[40] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[16]->in[41] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[16]->in[41] mux_2level_size50[16]->in[41] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[16]->in[42] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[16]->in[42] mux_2level_size50[16]->in[42] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[16]->in[43] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[16]->in[43] mux_2level_size50[16]->in[43] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[16]->in[44] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[16]->in[44] mux_2level_size50[16]->in[44] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[16]->in[45] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[16]->in[45] mux_2level_size50[16]->in[45] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[16]->in[46] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[16]->in[46] mux_2level_size50[16]->in[46] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[16]->in[47] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[16]->in[47] mux_2level_size50[16]->in[47] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[16]->in[48] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[16]->in[48] mux_2level_size50[16]->in[48] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[16]->in[49] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[16]->in[49] mux_2level_size50[16]->in[49] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
Vgvdd_mux_2level_size50[16] gvdd_mux_2level_size50[16] 0 vsp
***** Measurements *****
***** Rise delay *****
.meas tran delay_rise_idle_mux50[16]_in[4]_crossbar trig v(mux_2level_size50[16]->in[0]) val='input_thres_pct_rise*vsp' rise=1 td='clock_period'
+          targ v(mux_2level_size50[16]->out) val='output_thres_pct_rise*vsp' rise=1 td='clock_period'
***** Fall delay *****
.meas tran delay_fall_idle_mux50[16]_in[4]_crossbar trig v(mux_2level_size50[16]->in[0]) val='input_thres_pct_fall*vsp' fall=1 td='clock_period'
+          targ v(mux_2level_size50[16]->out) val='output_thres_pct_fall*vsp' fall=1 td='clock_period'
***** Rise timing period *****
.meas start_rise_idle_mux50[16]_in[4]_crossbar when v(mux_2level_size50[16]->in[0])='slew_lower_thres_pct_rise*vsp' rise=1 td='clock_period'
.meas tran switch_rise_idle_mux50[16]_in[4]_crossbar trig v(mux_2level_size50[16]->in[0]) val='slew_lower_thres_pct_rise*vsp' rise=1 td='clock_period'
+          targ v(mux_2level_size50[16]->out) val='slew_upper_thres_pct_rise*vsp' rise=1 td='clock_period'
***** Fall timing period *****
.meas start_fall_idle_mux50[16]_in[4]_crossbar when v(mux_2level_size50[16]->in[0])='slew_lower_thres_pct_fall*vsp' fall=1 td='clock_period'
.meas tran switch_fall_idle_mux50[16]_in[4]_crossbar trig v(mux_2level_size50[16]->in[0]) val='slew_lower_thres_pct_fall*vsp' fall=1 td='clock_period'
+          targ v(mux_2level_size50[16]->out) val='slew_upper_thres_pct_fall*vsp' fall=1 td='clock_period'
***** Leakage Power Measurement *****
.meas tran mux_2level_size50[16]_leakage_power avg p(Vgvdd_mux_2level_size50[16]) from=0 to='clock_period'
.meas tran leakage_idle_mux50[16]_in[4]_crossbar param='mux_2level_size50[16]_leakage_power'
***** Dynamic Power Measurement *****
.meas tran mux_2level_size50[16]_dynamic_power avg p(Vgvdd_mux_2level_size50[16]) from='clock_period' to='6*clock_period'
.meas tran mux_2level_size50[16]_energy_per_cycle param='mux_2level_size50[16]_dynamic_power*clock_period'
.meas tran dynamic_power_idle_mux50[16]_in[4]_crossbar  param='mux_2level_size50[16]_dynamic_power'
.meas tran energy_per_cycle_idle_mux50[16]_in[4]_crossbar  param='dynamic_power_idle_mux50[16]_in[4]_crossbar*clock_period'
.meas tran dynamic_rise_idle_mux50[16]_in[4]_crossbar avg p(Vgvdd_mux_2level_size50[16]) from='start_rise_idle_mux50[16]_in[4]_crossbar' to='start_rise_idle_mux50[16]_in[4]_crossbar+switch_rise_idle_mux50[16]_in[4]_crossbar'
.meas tran dynamic_fall_idle_mux50[16]_in[4]_crossbar avg p(Vgvdd_mux_2level_size50[16]) from='start_fall_idle_mux50[16]_in[4]_crossbar' to='start_fall_idle_mux50[16]_in[4]_crossbar+switch_fall_idle_mux50[16]_in[4]_crossbar'
.meas tran sum_leakage_power_mux[0to16]
+          param='sum_leakage_power_mux[0to15]+leakage_idle_mux50[16]_in[4]_crossbar'
.meas tran sum_energy_per_cycle_mux[0to16]
+          param='sum_energy_per_cycle_mux[0to15]+energy_per_cycle_idle_mux50[16]_in[4]_crossbar'
Xload_inv[16]_no0 mux_2level_size50[16]->out mux_2level_size50[16]->out_out[0] gvdd_load 0 inv size=5
.meas tran sum_leakage_power_pb_mux[0to16]
+          param='sum_leakage_power_pb_mux[0to15]+leakage_idle_mux50[16]_in[4]_crossbar'
.meas tran sum_energy_per_cycle_pb_mux[0to16]
+          param='sum_energy_per_cycle_pb_mux[0to15]+energy_per_cycle_idle_mux50[16]_in[4]_crossbar'
Xmux_2level_size50[17] mux_2level_size50[17]->in[0] mux_2level_size50[17]->in[1] mux_2level_size50[17]->in[2] mux_2level_size50[17]->in[3] mux_2level_size50[17]->in[4] mux_2level_size50[17]->in[5] mux_2level_size50[17]->in[6] mux_2level_size50[17]->in[7] mux_2level_size50[17]->in[8] mux_2level_size50[17]->in[9] mux_2level_size50[17]->in[10] mux_2level_size50[17]->in[11] mux_2level_size50[17]->in[12] mux_2level_size50[17]->in[13] mux_2level_size50[17]->in[14] mux_2level_size50[17]->in[15] mux_2level_size50[17]->in[16] mux_2level_size50[17]->in[17] mux_2level_size50[17]->in[18] mux_2level_size50[17]->in[19] mux_2level_size50[17]->in[20] mux_2level_size50[17]->in[21] mux_2level_size50[17]->in[22] mux_2level_size50[17]->in[23] mux_2level_size50[17]->in[24] mux_2level_size50[17]->in[25] mux_2level_size50[17]->in[26] mux_2level_size50[17]->in[27] mux_2level_size50[17]->in[28] mux_2level_size50[17]->in[29] mux_2level_size50[17]->in[30] mux_2level_size50[17]->in[31] mux_2level_size50[17]->in[32] mux_2level_size50[17]->in[33] mux_2level_size50[17]->in[34] mux_2level_size50[17]->in[35] mux_2level_size50[17]->in[36] mux_2level_size50[17]->in[37] mux_2level_size50[17]->in[38] mux_2level_size50[17]->in[39] mux_2level_size50[17]->in[40] mux_2level_size50[17]->in[41] mux_2level_size50[17]->in[42] mux_2level_size50[17]->in[43] mux_2level_size50[17]->in[44] mux_2level_size50[17]->in[45] mux_2level_size50[17]->in[46] mux_2level_size50[17]->in[47] mux_2level_size50[17]->in[48] mux_2level_size50[17]->in[49] mux_2level_size50[17]->out sram[272]->outb sram[272]->out sram[273]->out sram[273]->outb sram[274]->out sram[274]->outb sram[275]->out sram[275]->outb sram[276]->out sram[276]->outb sram[277]->out sram[277]->outb sram[278]->out sram[278]->outb sram[279]->out sram[279]->outb sram[280]->outb sram[280]->out sram[281]->out sram[281]->outb sram[282]->out sram[282]->outb sram[283]->out sram[283]->outb sram[284]->out sram[284]->outb sram[285]->out sram[285]->outb sram[286]->out sram[286]->outb sram[287]->out sram[287]->outb gvdd_mux_2level_size50[17] 0 mux_2level_size50
***** SRAM bits for MUX[17], level=2, select_path_id=0. *****
*****1000000010000000*****
Xsram[272] sram->in sram[272]->out sram[272]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[272]->out) 0
.nodeset V(sram[272]->outb) vsp
Xsram[273] sram->in sram[273]->out sram[273]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[273]->out) 0
.nodeset V(sram[273]->outb) vsp
Xsram[274] sram->in sram[274]->out sram[274]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[274]->out) 0
.nodeset V(sram[274]->outb) vsp
Xsram[275] sram->in sram[275]->out sram[275]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[275]->out) 0
.nodeset V(sram[275]->outb) vsp
Xsram[276] sram->in sram[276]->out sram[276]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[276]->out) 0
.nodeset V(sram[276]->outb) vsp
Xsram[277] sram->in sram[277]->out sram[277]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[277]->out) 0
.nodeset V(sram[277]->outb) vsp
Xsram[278] sram->in sram[278]->out sram[278]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[278]->out) 0
.nodeset V(sram[278]->outb) vsp
Xsram[279] sram->in sram[279]->out sram[279]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[279]->out) 0
.nodeset V(sram[279]->outb) vsp
Xsram[280] sram->in sram[280]->out sram[280]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[280]->out) 0
.nodeset V(sram[280]->outb) vsp
Xsram[281] sram->in sram[281]->out sram[281]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[281]->out) 0
.nodeset V(sram[281]->outb) vsp
Xsram[282] sram->in sram[282]->out sram[282]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[282]->out) 0
.nodeset V(sram[282]->outb) vsp
Xsram[283] sram->in sram[283]->out sram[283]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[283]->out) 0
.nodeset V(sram[283]->outb) vsp
Xsram[284] sram->in sram[284]->out sram[284]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[284]->out) 0
.nodeset V(sram[284]->outb) vsp
Xsram[285] sram->in sram[285]->out sram[285]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[285]->out) 0
.nodeset V(sram[285]->outb) vsp
Xsram[286] sram->in sram[286]->out sram[286]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[286]->out) 0
.nodeset V(sram[286]->outb) vsp
Xsram[287] sram->in sram[287]->out sram[287]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[287]->out) 0
.nodeset V(sram[287]->outb) vsp
***** Signal mux_2level_size50[17]->in[0] density = 0, probability=0.*****
Vmux_2level_size50[17]->in[0] mux_2level_size50[17]->in[0] 0
+  0
***** Signal mux_2level_size50[17]->in[1] density = 0, probability=0.*****
Vmux_2level_size50[17]->in[1] mux_2level_size50[17]->in[1] 0
+  0
***** Signal mux_2level_size50[17]->in[2] density = 0, probability=0.*****
Vmux_2level_size50[17]->in[2] mux_2level_size50[17]->in[2] 0
+  0
***** Signal mux_2level_size50[17]->in[3] density = 0, probability=0.*****
Vmux_2level_size50[17]->in[3] mux_2level_size50[17]->in[3] 0
+  0
***** Signal mux_2level_size50[17]->in[4] density = 0, probability=0.*****
Vmux_2level_size50[17]->in[4] mux_2level_size50[17]->in[4] 0
+  0
***** Signal mux_2level_size50[17]->in[5] density = 0, probability=0.*****
Vmux_2level_size50[17]->in[5] mux_2level_size50[17]->in[5] 0
+  0
***** Signal mux_2level_size50[17]->in[6] density = 0, probability=0.*****
Vmux_2level_size50[17]->in[6] mux_2level_size50[17]->in[6] 0
+  0
***** Signal mux_2level_size50[17]->in[7] density = 0, probability=0.*****
Vmux_2level_size50[17]->in[7] mux_2level_size50[17]->in[7] 0
+  0
***** Signal mux_2level_size50[17]->in[8] density = 0, probability=0.*****
Vmux_2level_size50[17]->in[8] mux_2level_size50[17]->in[8] 0
+  0
***** Signal mux_2level_size50[17]->in[9] density = 0, probability=0.*****
Vmux_2level_size50[17]->in[9] mux_2level_size50[17]->in[9] 0
+  0
***** Signal mux_2level_size50[17]->in[10] density = 0, probability=0.*****
Vmux_2level_size50[17]->in[10] mux_2level_size50[17]->in[10] 0
+  0
***** Signal mux_2level_size50[17]->in[11] density = 0, probability=0.*****
Vmux_2level_size50[17]->in[11] mux_2level_size50[17]->in[11] 0
+  0
***** Signal mux_2level_size50[17]->in[12] density = 0, probability=0.*****
Vmux_2level_size50[17]->in[12] mux_2level_size50[17]->in[12] 0
+  0
***** Signal mux_2level_size50[17]->in[13] density = 0, probability=0.*****
Vmux_2level_size50[17]->in[13] mux_2level_size50[17]->in[13] 0
+  0
***** Signal mux_2level_size50[17]->in[14] density = 0, probability=0.*****
Vmux_2level_size50[17]->in[14] mux_2level_size50[17]->in[14] 0
+  0
***** Signal mux_2level_size50[17]->in[15] density = 0, probability=0.*****
Vmux_2level_size50[17]->in[15] mux_2level_size50[17]->in[15] 0
+  0
***** Signal mux_2level_size50[17]->in[16] density = 0, probability=0.*****
Vmux_2level_size50[17]->in[16] mux_2level_size50[17]->in[16] 0
+  0
***** Signal mux_2level_size50[17]->in[17] density = 0, probability=0.*****
Vmux_2level_size50[17]->in[17] mux_2level_size50[17]->in[17] 0
+  0
***** Signal mux_2level_size50[17]->in[18] density = 0, probability=0.*****
Vmux_2level_size50[17]->in[18] mux_2level_size50[17]->in[18] 0
+  0
***** Signal mux_2level_size50[17]->in[19] density = 0, probability=0.*****
Vmux_2level_size50[17]->in[19] mux_2level_size50[17]->in[19] 0
+  0
***** Signal mux_2level_size50[17]->in[20] density = 0, probability=0.*****
Vmux_2level_size50[17]->in[20] mux_2level_size50[17]->in[20] 0
+  0
***** Signal mux_2level_size50[17]->in[21] density = 0, probability=0.*****
Vmux_2level_size50[17]->in[21] mux_2level_size50[17]->in[21] 0
+  0
***** Signal mux_2level_size50[17]->in[22] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[17]->in[22] mux_2level_size50[17]->in[22] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[17]->in[23] density = 0, probability=0.*****
Vmux_2level_size50[17]->in[23] mux_2level_size50[17]->in[23] 0
+  0
***** Signal mux_2level_size50[17]->in[24] density = 0, probability=0.*****
Vmux_2level_size50[17]->in[24] mux_2level_size50[17]->in[24] 0
+  0
***** Signal mux_2level_size50[17]->in[25] density = 0, probability=0.*****
Vmux_2level_size50[17]->in[25] mux_2level_size50[17]->in[25] 0
+  0
***** Signal mux_2level_size50[17]->in[26] density = 0, probability=0.*****
Vmux_2level_size50[17]->in[26] mux_2level_size50[17]->in[26] 0
+  0
***** Signal mux_2level_size50[17]->in[27] density = 0, probability=0.*****
Vmux_2level_size50[17]->in[27] mux_2level_size50[17]->in[27] 0
+  0
***** Signal mux_2level_size50[17]->in[28] density = 0, probability=0.*****
Vmux_2level_size50[17]->in[28] mux_2level_size50[17]->in[28] 0
+  0
***** Signal mux_2level_size50[17]->in[29] density = 0, probability=0.*****
Vmux_2level_size50[17]->in[29] mux_2level_size50[17]->in[29] 0
+  0
***** Signal mux_2level_size50[17]->in[30] density = 0, probability=0.*****
Vmux_2level_size50[17]->in[30] mux_2level_size50[17]->in[30] 0
+  0
***** Signal mux_2level_size50[17]->in[31] density = 0, probability=0.*****
Vmux_2level_size50[17]->in[31] mux_2level_size50[17]->in[31] 0
+  0
***** Signal mux_2level_size50[17]->in[32] density = 0, probability=0.*****
Vmux_2level_size50[17]->in[32] mux_2level_size50[17]->in[32] 0
+  0
***** Signal mux_2level_size50[17]->in[33] density = 0, probability=0.*****
Vmux_2level_size50[17]->in[33] mux_2level_size50[17]->in[33] 0
+  0
***** Signal mux_2level_size50[17]->in[34] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[17]->in[34] mux_2level_size50[17]->in[34] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[17]->in[35] density = 0, probability=0.*****
Vmux_2level_size50[17]->in[35] mux_2level_size50[17]->in[35] 0
+  0
***** Signal mux_2level_size50[17]->in[36] density = 0, probability=0.*****
Vmux_2level_size50[17]->in[36] mux_2level_size50[17]->in[36] 0
+  0
***** Signal mux_2level_size50[17]->in[37] density = 0, probability=0.*****
Vmux_2level_size50[17]->in[37] mux_2level_size50[17]->in[37] 0
+  0
***** Signal mux_2level_size50[17]->in[38] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[17]->in[38] mux_2level_size50[17]->in[38] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[17]->in[39] density = 0, probability=0.*****
Vmux_2level_size50[17]->in[39] mux_2level_size50[17]->in[39] 0
+  0
***** Signal mux_2level_size50[17]->in[40] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[17]->in[40] mux_2level_size50[17]->in[40] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[17]->in[41] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[17]->in[41] mux_2level_size50[17]->in[41] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[17]->in[42] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[17]->in[42] mux_2level_size50[17]->in[42] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[17]->in[43] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[17]->in[43] mux_2level_size50[17]->in[43] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[17]->in[44] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[17]->in[44] mux_2level_size50[17]->in[44] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[17]->in[45] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[17]->in[45] mux_2level_size50[17]->in[45] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[17]->in[46] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[17]->in[46] mux_2level_size50[17]->in[46] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[17]->in[47] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[17]->in[47] mux_2level_size50[17]->in[47] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[17]->in[48] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[17]->in[48] mux_2level_size50[17]->in[48] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[17]->in[49] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[17]->in[49] mux_2level_size50[17]->in[49] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
Vgvdd_mux_2level_size50[17] gvdd_mux_2level_size50[17] 0 vsp
***** Measurements *****
***** Rise delay *****
.meas tran delay_rise_idle_mux50[17]_in[5]_crossbar trig v(mux_2level_size50[17]->in[0]) val='input_thres_pct_rise*vsp' rise=1 td='clock_period'
+          targ v(mux_2level_size50[17]->out) val='output_thres_pct_rise*vsp' rise=1 td='clock_period'
***** Fall delay *****
.meas tran delay_fall_idle_mux50[17]_in[5]_crossbar trig v(mux_2level_size50[17]->in[0]) val='input_thres_pct_fall*vsp' fall=1 td='clock_period'
+          targ v(mux_2level_size50[17]->out) val='output_thres_pct_fall*vsp' fall=1 td='clock_period'
***** Rise timing period *****
.meas start_rise_idle_mux50[17]_in[5]_crossbar when v(mux_2level_size50[17]->in[0])='slew_lower_thres_pct_rise*vsp' rise=1 td='clock_period'
.meas tran switch_rise_idle_mux50[17]_in[5]_crossbar trig v(mux_2level_size50[17]->in[0]) val='slew_lower_thres_pct_rise*vsp' rise=1 td='clock_period'
+          targ v(mux_2level_size50[17]->out) val='slew_upper_thres_pct_rise*vsp' rise=1 td='clock_period'
***** Fall timing period *****
.meas start_fall_idle_mux50[17]_in[5]_crossbar when v(mux_2level_size50[17]->in[0])='slew_lower_thres_pct_fall*vsp' fall=1 td='clock_period'
.meas tran switch_fall_idle_mux50[17]_in[5]_crossbar trig v(mux_2level_size50[17]->in[0]) val='slew_lower_thres_pct_fall*vsp' fall=1 td='clock_period'
+          targ v(mux_2level_size50[17]->out) val='slew_upper_thres_pct_fall*vsp' fall=1 td='clock_period'
***** Leakage Power Measurement *****
.meas tran mux_2level_size50[17]_leakage_power avg p(Vgvdd_mux_2level_size50[17]) from=0 to='clock_period'
.meas tran leakage_idle_mux50[17]_in[5]_crossbar param='mux_2level_size50[17]_leakage_power'
***** Dynamic Power Measurement *****
.meas tran mux_2level_size50[17]_dynamic_power avg p(Vgvdd_mux_2level_size50[17]) from='clock_period' to='6*clock_period'
.meas tran mux_2level_size50[17]_energy_per_cycle param='mux_2level_size50[17]_dynamic_power*clock_period'
.meas tran dynamic_power_idle_mux50[17]_in[5]_crossbar  param='mux_2level_size50[17]_dynamic_power'
.meas tran energy_per_cycle_idle_mux50[17]_in[5]_crossbar  param='dynamic_power_idle_mux50[17]_in[5]_crossbar*clock_period'
.meas tran dynamic_rise_idle_mux50[17]_in[5]_crossbar avg p(Vgvdd_mux_2level_size50[17]) from='start_rise_idle_mux50[17]_in[5]_crossbar' to='start_rise_idle_mux50[17]_in[5]_crossbar+switch_rise_idle_mux50[17]_in[5]_crossbar'
.meas tran dynamic_fall_idle_mux50[17]_in[5]_crossbar avg p(Vgvdd_mux_2level_size50[17]) from='start_fall_idle_mux50[17]_in[5]_crossbar' to='start_fall_idle_mux50[17]_in[5]_crossbar+switch_fall_idle_mux50[17]_in[5]_crossbar'
.meas tran sum_leakage_power_mux[0to17]
+          param='sum_leakage_power_mux[0to16]+leakage_idle_mux50[17]_in[5]_crossbar'
.meas tran sum_energy_per_cycle_mux[0to17]
+          param='sum_energy_per_cycle_mux[0to16]+energy_per_cycle_idle_mux50[17]_in[5]_crossbar'
Xload_inv[17]_no0 mux_2level_size50[17]->out mux_2level_size50[17]->out_out[0] gvdd_load 0 inv size=5
.meas tran sum_leakage_power_pb_mux[0to17]
+          param='sum_leakage_power_pb_mux[0to16]+leakage_idle_mux50[17]_in[5]_crossbar'
.meas tran sum_energy_per_cycle_pb_mux[0to17]
+          param='sum_energy_per_cycle_pb_mux[0to16]+energy_per_cycle_idle_mux50[17]_in[5]_crossbar'
Xmux_2level_size50[18] mux_2level_size50[18]->in[0] mux_2level_size50[18]->in[1] mux_2level_size50[18]->in[2] mux_2level_size50[18]->in[3] mux_2level_size50[18]->in[4] mux_2level_size50[18]->in[5] mux_2level_size50[18]->in[6] mux_2level_size50[18]->in[7] mux_2level_size50[18]->in[8] mux_2level_size50[18]->in[9] mux_2level_size50[18]->in[10] mux_2level_size50[18]->in[11] mux_2level_size50[18]->in[12] mux_2level_size50[18]->in[13] mux_2level_size50[18]->in[14] mux_2level_size50[18]->in[15] mux_2level_size50[18]->in[16] mux_2level_size50[18]->in[17] mux_2level_size50[18]->in[18] mux_2level_size50[18]->in[19] mux_2level_size50[18]->in[20] mux_2level_size50[18]->in[21] mux_2level_size50[18]->in[22] mux_2level_size50[18]->in[23] mux_2level_size50[18]->in[24] mux_2level_size50[18]->in[25] mux_2level_size50[18]->in[26] mux_2level_size50[18]->in[27] mux_2level_size50[18]->in[28] mux_2level_size50[18]->in[29] mux_2level_size50[18]->in[30] mux_2level_size50[18]->in[31] mux_2level_size50[18]->in[32] mux_2level_size50[18]->in[33] mux_2level_size50[18]->in[34] mux_2level_size50[18]->in[35] mux_2level_size50[18]->in[36] mux_2level_size50[18]->in[37] mux_2level_size50[18]->in[38] mux_2level_size50[18]->in[39] mux_2level_size50[18]->in[40] mux_2level_size50[18]->in[41] mux_2level_size50[18]->in[42] mux_2level_size50[18]->in[43] mux_2level_size50[18]->in[44] mux_2level_size50[18]->in[45] mux_2level_size50[18]->in[46] mux_2level_size50[18]->in[47] mux_2level_size50[18]->in[48] mux_2level_size50[18]->in[49] mux_2level_size50[18]->out sram[288]->outb sram[288]->out sram[289]->out sram[289]->outb sram[290]->out sram[290]->outb sram[291]->out sram[291]->outb sram[292]->out sram[292]->outb sram[293]->out sram[293]->outb sram[294]->out sram[294]->outb sram[295]->out sram[295]->outb sram[296]->outb sram[296]->out sram[297]->out sram[297]->outb sram[298]->out sram[298]->outb sram[299]->out sram[299]->outb sram[300]->out sram[300]->outb sram[301]->out sram[301]->outb sram[302]->out sram[302]->outb sram[303]->out sram[303]->outb gvdd_mux_2level_size50[18] 0 mux_2level_size50
***** SRAM bits for MUX[18], level=2, select_path_id=0. *****
*****1000000010000000*****
Xsram[288] sram->in sram[288]->out sram[288]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[288]->out) 0
.nodeset V(sram[288]->outb) vsp
Xsram[289] sram->in sram[289]->out sram[289]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[289]->out) 0
.nodeset V(sram[289]->outb) vsp
Xsram[290] sram->in sram[290]->out sram[290]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[290]->out) 0
.nodeset V(sram[290]->outb) vsp
Xsram[291] sram->in sram[291]->out sram[291]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[291]->out) 0
.nodeset V(sram[291]->outb) vsp
Xsram[292] sram->in sram[292]->out sram[292]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[292]->out) 0
.nodeset V(sram[292]->outb) vsp
Xsram[293] sram->in sram[293]->out sram[293]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[293]->out) 0
.nodeset V(sram[293]->outb) vsp
Xsram[294] sram->in sram[294]->out sram[294]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[294]->out) 0
.nodeset V(sram[294]->outb) vsp
Xsram[295] sram->in sram[295]->out sram[295]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[295]->out) 0
.nodeset V(sram[295]->outb) vsp
Xsram[296] sram->in sram[296]->out sram[296]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[296]->out) 0
.nodeset V(sram[296]->outb) vsp
Xsram[297] sram->in sram[297]->out sram[297]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[297]->out) 0
.nodeset V(sram[297]->outb) vsp
Xsram[298] sram->in sram[298]->out sram[298]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[298]->out) 0
.nodeset V(sram[298]->outb) vsp
Xsram[299] sram->in sram[299]->out sram[299]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[299]->out) 0
.nodeset V(sram[299]->outb) vsp
Xsram[300] sram->in sram[300]->out sram[300]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[300]->out) 0
.nodeset V(sram[300]->outb) vsp
Xsram[301] sram->in sram[301]->out sram[301]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[301]->out) 0
.nodeset V(sram[301]->outb) vsp
Xsram[302] sram->in sram[302]->out sram[302]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[302]->out) 0
.nodeset V(sram[302]->outb) vsp
Xsram[303] sram->in sram[303]->out sram[303]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[303]->out) 0
.nodeset V(sram[303]->outb) vsp
***** Signal mux_2level_size50[18]->in[0] density = 0, probability=0.*****
Vmux_2level_size50[18]->in[0] mux_2level_size50[18]->in[0] 0
+  0
***** Signal mux_2level_size50[18]->in[1] density = 0, probability=0.*****
Vmux_2level_size50[18]->in[1] mux_2level_size50[18]->in[1] 0
+  0
***** Signal mux_2level_size50[18]->in[2] density = 0, probability=0.*****
Vmux_2level_size50[18]->in[2] mux_2level_size50[18]->in[2] 0
+  0
***** Signal mux_2level_size50[18]->in[3] density = 0, probability=0.*****
Vmux_2level_size50[18]->in[3] mux_2level_size50[18]->in[3] 0
+  0
***** Signal mux_2level_size50[18]->in[4] density = 0, probability=0.*****
Vmux_2level_size50[18]->in[4] mux_2level_size50[18]->in[4] 0
+  0
***** Signal mux_2level_size50[18]->in[5] density = 0, probability=0.*****
Vmux_2level_size50[18]->in[5] mux_2level_size50[18]->in[5] 0
+  0
***** Signal mux_2level_size50[18]->in[6] density = 0, probability=0.*****
Vmux_2level_size50[18]->in[6] mux_2level_size50[18]->in[6] 0
+  0
***** Signal mux_2level_size50[18]->in[7] density = 0, probability=0.*****
Vmux_2level_size50[18]->in[7] mux_2level_size50[18]->in[7] 0
+  0
***** Signal mux_2level_size50[18]->in[8] density = 0, probability=0.*****
Vmux_2level_size50[18]->in[8] mux_2level_size50[18]->in[8] 0
+  0
***** Signal mux_2level_size50[18]->in[9] density = 0, probability=0.*****
Vmux_2level_size50[18]->in[9] mux_2level_size50[18]->in[9] 0
+  0
***** Signal mux_2level_size50[18]->in[10] density = 0, probability=0.*****
Vmux_2level_size50[18]->in[10] mux_2level_size50[18]->in[10] 0
+  0
***** Signal mux_2level_size50[18]->in[11] density = 0, probability=0.*****
Vmux_2level_size50[18]->in[11] mux_2level_size50[18]->in[11] 0
+  0
***** Signal mux_2level_size50[18]->in[12] density = 0, probability=0.*****
Vmux_2level_size50[18]->in[12] mux_2level_size50[18]->in[12] 0
+  0
***** Signal mux_2level_size50[18]->in[13] density = 0, probability=0.*****
Vmux_2level_size50[18]->in[13] mux_2level_size50[18]->in[13] 0
+  0
***** Signal mux_2level_size50[18]->in[14] density = 0, probability=0.*****
Vmux_2level_size50[18]->in[14] mux_2level_size50[18]->in[14] 0
+  0
***** Signal mux_2level_size50[18]->in[15] density = 0, probability=0.*****
Vmux_2level_size50[18]->in[15] mux_2level_size50[18]->in[15] 0
+  0
***** Signal mux_2level_size50[18]->in[16] density = 0, probability=0.*****
Vmux_2level_size50[18]->in[16] mux_2level_size50[18]->in[16] 0
+  0
***** Signal mux_2level_size50[18]->in[17] density = 0, probability=0.*****
Vmux_2level_size50[18]->in[17] mux_2level_size50[18]->in[17] 0
+  0
***** Signal mux_2level_size50[18]->in[18] density = 0, probability=0.*****
Vmux_2level_size50[18]->in[18] mux_2level_size50[18]->in[18] 0
+  0
***** Signal mux_2level_size50[18]->in[19] density = 0, probability=0.*****
Vmux_2level_size50[18]->in[19] mux_2level_size50[18]->in[19] 0
+  0
***** Signal mux_2level_size50[18]->in[20] density = 0, probability=0.*****
Vmux_2level_size50[18]->in[20] mux_2level_size50[18]->in[20] 0
+  0
***** Signal mux_2level_size50[18]->in[21] density = 0, probability=0.*****
Vmux_2level_size50[18]->in[21] mux_2level_size50[18]->in[21] 0
+  0
***** Signal mux_2level_size50[18]->in[22] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[18]->in[22] mux_2level_size50[18]->in[22] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[18]->in[23] density = 0, probability=0.*****
Vmux_2level_size50[18]->in[23] mux_2level_size50[18]->in[23] 0
+  0
***** Signal mux_2level_size50[18]->in[24] density = 0, probability=0.*****
Vmux_2level_size50[18]->in[24] mux_2level_size50[18]->in[24] 0
+  0
***** Signal mux_2level_size50[18]->in[25] density = 0, probability=0.*****
Vmux_2level_size50[18]->in[25] mux_2level_size50[18]->in[25] 0
+  0
***** Signal mux_2level_size50[18]->in[26] density = 0, probability=0.*****
Vmux_2level_size50[18]->in[26] mux_2level_size50[18]->in[26] 0
+  0
***** Signal mux_2level_size50[18]->in[27] density = 0, probability=0.*****
Vmux_2level_size50[18]->in[27] mux_2level_size50[18]->in[27] 0
+  0
***** Signal mux_2level_size50[18]->in[28] density = 0, probability=0.*****
Vmux_2level_size50[18]->in[28] mux_2level_size50[18]->in[28] 0
+  0
***** Signal mux_2level_size50[18]->in[29] density = 0, probability=0.*****
Vmux_2level_size50[18]->in[29] mux_2level_size50[18]->in[29] 0
+  0
***** Signal mux_2level_size50[18]->in[30] density = 0, probability=0.*****
Vmux_2level_size50[18]->in[30] mux_2level_size50[18]->in[30] 0
+  0
***** Signal mux_2level_size50[18]->in[31] density = 0, probability=0.*****
Vmux_2level_size50[18]->in[31] mux_2level_size50[18]->in[31] 0
+  0
***** Signal mux_2level_size50[18]->in[32] density = 0, probability=0.*****
Vmux_2level_size50[18]->in[32] mux_2level_size50[18]->in[32] 0
+  0
***** Signal mux_2level_size50[18]->in[33] density = 0, probability=0.*****
Vmux_2level_size50[18]->in[33] mux_2level_size50[18]->in[33] 0
+  0
***** Signal mux_2level_size50[18]->in[34] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[18]->in[34] mux_2level_size50[18]->in[34] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[18]->in[35] density = 0, probability=0.*****
Vmux_2level_size50[18]->in[35] mux_2level_size50[18]->in[35] 0
+  0
***** Signal mux_2level_size50[18]->in[36] density = 0, probability=0.*****
Vmux_2level_size50[18]->in[36] mux_2level_size50[18]->in[36] 0
+  0
***** Signal mux_2level_size50[18]->in[37] density = 0, probability=0.*****
Vmux_2level_size50[18]->in[37] mux_2level_size50[18]->in[37] 0
+  0
***** Signal mux_2level_size50[18]->in[38] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[18]->in[38] mux_2level_size50[18]->in[38] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[18]->in[39] density = 0, probability=0.*****
Vmux_2level_size50[18]->in[39] mux_2level_size50[18]->in[39] 0
+  0
***** Signal mux_2level_size50[18]->in[40] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[18]->in[40] mux_2level_size50[18]->in[40] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[18]->in[41] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[18]->in[41] mux_2level_size50[18]->in[41] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[18]->in[42] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[18]->in[42] mux_2level_size50[18]->in[42] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[18]->in[43] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[18]->in[43] mux_2level_size50[18]->in[43] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[18]->in[44] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[18]->in[44] mux_2level_size50[18]->in[44] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[18]->in[45] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[18]->in[45] mux_2level_size50[18]->in[45] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[18]->in[46] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[18]->in[46] mux_2level_size50[18]->in[46] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[18]->in[47] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[18]->in[47] mux_2level_size50[18]->in[47] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[18]->in[48] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[18]->in[48] mux_2level_size50[18]->in[48] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[18]->in[49] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[18]->in[49] mux_2level_size50[18]->in[49] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
Vgvdd_mux_2level_size50[18] gvdd_mux_2level_size50[18] 0 vsp
***** Measurements *****
***** Rise delay *****
.meas tran delay_rise_idle_mux50[18]_in[0]_crossbar trig v(mux_2level_size50[18]->in[0]) val='input_thres_pct_rise*vsp' rise=1 td='clock_period'
+          targ v(mux_2level_size50[18]->out) val='output_thres_pct_rise*vsp' rise=1 td='clock_period'
***** Fall delay *****
.meas tran delay_fall_idle_mux50[18]_in[0]_crossbar trig v(mux_2level_size50[18]->in[0]) val='input_thres_pct_fall*vsp' fall=1 td='clock_period'
+          targ v(mux_2level_size50[18]->out) val='output_thres_pct_fall*vsp' fall=1 td='clock_period'
***** Rise timing period *****
.meas start_rise_idle_mux50[18]_in[0]_crossbar when v(mux_2level_size50[18]->in[0])='slew_lower_thres_pct_rise*vsp' rise=1 td='clock_period'
.meas tran switch_rise_idle_mux50[18]_in[0]_crossbar trig v(mux_2level_size50[18]->in[0]) val='slew_lower_thres_pct_rise*vsp' rise=1 td='clock_period'
+          targ v(mux_2level_size50[18]->out) val='slew_upper_thres_pct_rise*vsp' rise=1 td='clock_period'
***** Fall timing period *****
.meas start_fall_idle_mux50[18]_in[0]_crossbar when v(mux_2level_size50[18]->in[0])='slew_lower_thres_pct_fall*vsp' fall=1 td='clock_period'
.meas tran switch_fall_idle_mux50[18]_in[0]_crossbar trig v(mux_2level_size50[18]->in[0]) val='slew_lower_thres_pct_fall*vsp' fall=1 td='clock_period'
+          targ v(mux_2level_size50[18]->out) val='slew_upper_thres_pct_fall*vsp' fall=1 td='clock_period'
***** Leakage Power Measurement *****
.meas tran mux_2level_size50[18]_leakage_power avg p(Vgvdd_mux_2level_size50[18]) from=0 to='clock_period'
.meas tran leakage_idle_mux50[18]_in[0]_crossbar param='mux_2level_size50[18]_leakage_power'
***** Dynamic Power Measurement *****
.meas tran mux_2level_size50[18]_dynamic_power avg p(Vgvdd_mux_2level_size50[18]) from='clock_period' to='6*clock_period'
.meas tran mux_2level_size50[18]_energy_per_cycle param='mux_2level_size50[18]_dynamic_power*clock_period'
.meas tran dynamic_power_idle_mux50[18]_in[0]_crossbar  param='mux_2level_size50[18]_dynamic_power'
.meas tran energy_per_cycle_idle_mux50[18]_in[0]_crossbar  param='dynamic_power_idle_mux50[18]_in[0]_crossbar*clock_period'
.meas tran dynamic_rise_idle_mux50[18]_in[0]_crossbar avg p(Vgvdd_mux_2level_size50[18]) from='start_rise_idle_mux50[18]_in[0]_crossbar' to='start_rise_idle_mux50[18]_in[0]_crossbar+switch_rise_idle_mux50[18]_in[0]_crossbar'
.meas tran dynamic_fall_idle_mux50[18]_in[0]_crossbar avg p(Vgvdd_mux_2level_size50[18]) from='start_fall_idle_mux50[18]_in[0]_crossbar' to='start_fall_idle_mux50[18]_in[0]_crossbar+switch_fall_idle_mux50[18]_in[0]_crossbar'
.meas tran sum_leakage_power_mux[0to18]
+          param='sum_leakage_power_mux[0to17]+leakage_idle_mux50[18]_in[0]_crossbar'
.meas tran sum_energy_per_cycle_mux[0to18]
+          param='sum_energy_per_cycle_mux[0to17]+energy_per_cycle_idle_mux50[18]_in[0]_crossbar'
Xload_inv[18]_no0 mux_2level_size50[18]->out mux_2level_size50[18]->out_out[0] gvdd_load 0 inv size=5
.meas tran sum_leakage_power_pb_mux[0to18]
+          param='sum_leakage_power_pb_mux[0to17]+leakage_idle_mux50[18]_in[0]_crossbar'
.meas tran sum_energy_per_cycle_pb_mux[0to18]
+          param='sum_energy_per_cycle_pb_mux[0to17]+energy_per_cycle_idle_mux50[18]_in[0]_crossbar'
Xmux_2level_size50[19] mux_2level_size50[19]->in[0] mux_2level_size50[19]->in[1] mux_2level_size50[19]->in[2] mux_2level_size50[19]->in[3] mux_2level_size50[19]->in[4] mux_2level_size50[19]->in[5] mux_2level_size50[19]->in[6] mux_2level_size50[19]->in[7] mux_2level_size50[19]->in[8] mux_2level_size50[19]->in[9] mux_2level_size50[19]->in[10] mux_2level_size50[19]->in[11] mux_2level_size50[19]->in[12] mux_2level_size50[19]->in[13] mux_2level_size50[19]->in[14] mux_2level_size50[19]->in[15] mux_2level_size50[19]->in[16] mux_2level_size50[19]->in[17] mux_2level_size50[19]->in[18] mux_2level_size50[19]->in[19] mux_2level_size50[19]->in[20] mux_2level_size50[19]->in[21] mux_2level_size50[19]->in[22] mux_2level_size50[19]->in[23] mux_2level_size50[19]->in[24] mux_2level_size50[19]->in[25] mux_2level_size50[19]->in[26] mux_2level_size50[19]->in[27] mux_2level_size50[19]->in[28] mux_2level_size50[19]->in[29] mux_2level_size50[19]->in[30] mux_2level_size50[19]->in[31] mux_2level_size50[19]->in[32] mux_2level_size50[19]->in[33] mux_2level_size50[19]->in[34] mux_2level_size50[19]->in[35] mux_2level_size50[19]->in[36] mux_2level_size50[19]->in[37] mux_2level_size50[19]->in[38] mux_2level_size50[19]->in[39] mux_2level_size50[19]->in[40] mux_2level_size50[19]->in[41] mux_2level_size50[19]->in[42] mux_2level_size50[19]->in[43] mux_2level_size50[19]->in[44] mux_2level_size50[19]->in[45] mux_2level_size50[19]->in[46] mux_2level_size50[19]->in[47] mux_2level_size50[19]->in[48] mux_2level_size50[19]->in[49] mux_2level_size50[19]->out sram[304]->outb sram[304]->out sram[305]->out sram[305]->outb sram[306]->out sram[306]->outb sram[307]->out sram[307]->outb sram[308]->out sram[308]->outb sram[309]->out sram[309]->outb sram[310]->out sram[310]->outb sram[311]->out sram[311]->outb sram[312]->outb sram[312]->out sram[313]->out sram[313]->outb sram[314]->out sram[314]->outb sram[315]->out sram[315]->outb sram[316]->out sram[316]->outb sram[317]->out sram[317]->outb sram[318]->out sram[318]->outb sram[319]->out sram[319]->outb gvdd_mux_2level_size50[19] 0 mux_2level_size50
***** SRAM bits for MUX[19], level=2, select_path_id=0. *****
*****1000000010000000*****
Xsram[304] sram->in sram[304]->out sram[304]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[304]->out) 0
.nodeset V(sram[304]->outb) vsp
Xsram[305] sram->in sram[305]->out sram[305]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[305]->out) 0
.nodeset V(sram[305]->outb) vsp
Xsram[306] sram->in sram[306]->out sram[306]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[306]->out) 0
.nodeset V(sram[306]->outb) vsp
Xsram[307] sram->in sram[307]->out sram[307]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[307]->out) 0
.nodeset V(sram[307]->outb) vsp
Xsram[308] sram->in sram[308]->out sram[308]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[308]->out) 0
.nodeset V(sram[308]->outb) vsp
Xsram[309] sram->in sram[309]->out sram[309]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[309]->out) 0
.nodeset V(sram[309]->outb) vsp
Xsram[310] sram->in sram[310]->out sram[310]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[310]->out) 0
.nodeset V(sram[310]->outb) vsp
Xsram[311] sram->in sram[311]->out sram[311]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[311]->out) 0
.nodeset V(sram[311]->outb) vsp
Xsram[312] sram->in sram[312]->out sram[312]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[312]->out) 0
.nodeset V(sram[312]->outb) vsp
Xsram[313] sram->in sram[313]->out sram[313]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[313]->out) 0
.nodeset V(sram[313]->outb) vsp
Xsram[314] sram->in sram[314]->out sram[314]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[314]->out) 0
.nodeset V(sram[314]->outb) vsp
Xsram[315] sram->in sram[315]->out sram[315]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[315]->out) 0
.nodeset V(sram[315]->outb) vsp
Xsram[316] sram->in sram[316]->out sram[316]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[316]->out) 0
.nodeset V(sram[316]->outb) vsp
Xsram[317] sram->in sram[317]->out sram[317]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[317]->out) 0
.nodeset V(sram[317]->outb) vsp
Xsram[318] sram->in sram[318]->out sram[318]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[318]->out) 0
.nodeset V(sram[318]->outb) vsp
Xsram[319] sram->in sram[319]->out sram[319]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[319]->out) 0
.nodeset V(sram[319]->outb) vsp
***** Signal mux_2level_size50[19]->in[0] density = 0, probability=0.*****
Vmux_2level_size50[19]->in[0] mux_2level_size50[19]->in[0] 0
+  0
***** Signal mux_2level_size50[19]->in[1] density = 0, probability=0.*****
Vmux_2level_size50[19]->in[1] mux_2level_size50[19]->in[1] 0
+  0
***** Signal mux_2level_size50[19]->in[2] density = 0, probability=0.*****
Vmux_2level_size50[19]->in[2] mux_2level_size50[19]->in[2] 0
+  0
***** Signal mux_2level_size50[19]->in[3] density = 0, probability=0.*****
Vmux_2level_size50[19]->in[3] mux_2level_size50[19]->in[3] 0
+  0
***** Signal mux_2level_size50[19]->in[4] density = 0, probability=0.*****
Vmux_2level_size50[19]->in[4] mux_2level_size50[19]->in[4] 0
+  0
***** Signal mux_2level_size50[19]->in[5] density = 0, probability=0.*****
Vmux_2level_size50[19]->in[5] mux_2level_size50[19]->in[5] 0
+  0
***** Signal mux_2level_size50[19]->in[6] density = 0, probability=0.*****
Vmux_2level_size50[19]->in[6] mux_2level_size50[19]->in[6] 0
+  0
***** Signal mux_2level_size50[19]->in[7] density = 0, probability=0.*****
Vmux_2level_size50[19]->in[7] mux_2level_size50[19]->in[7] 0
+  0
***** Signal mux_2level_size50[19]->in[8] density = 0, probability=0.*****
Vmux_2level_size50[19]->in[8] mux_2level_size50[19]->in[8] 0
+  0
***** Signal mux_2level_size50[19]->in[9] density = 0, probability=0.*****
Vmux_2level_size50[19]->in[9] mux_2level_size50[19]->in[9] 0
+  0
***** Signal mux_2level_size50[19]->in[10] density = 0, probability=0.*****
Vmux_2level_size50[19]->in[10] mux_2level_size50[19]->in[10] 0
+  0
***** Signal mux_2level_size50[19]->in[11] density = 0, probability=0.*****
Vmux_2level_size50[19]->in[11] mux_2level_size50[19]->in[11] 0
+  0
***** Signal mux_2level_size50[19]->in[12] density = 0, probability=0.*****
Vmux_2level_size50[19]->in[12] mux_2level_size50[19]->in[12] 0
+  0
***** Signal mux_2level_size50[19]->in[13] density = 0, probability=0.*****
Vmux_2level_size50[19]->in[13] mux_2level_size50[19]->in[13] 0
+  0
***** Signal mux_2level_size50[19]->in[14] density = 0, probability=0.*****
Vmux_2level_size50[19]->in[14] mux_2level_size50[19]->in[14] 0
+  0
***** Signal mux_2level_size50[19]->in[15] density = 0, probability=0.*****
Vmux_2level_size50[19]->in[15] mux_2level_size50[19]->in[15] 0
+  0
***** Signal mux_2level_size50[19]->in[16] density = 0, probability=0.*****
Vmux_2level_size50[19]->in[16] mux_2level_size50[19]->in[16] 0
+  0
***** Signal mux_2level_size50[19]->in[17] density = 0, probability=0.*****
Vmux_2level_size50[19]->in[17] mux_2level_size50[19]->in[17] 0
+  0
***** Signal mux_2level_size50[19]->in[18] density = 0, probability=0.*****
Vmux_2level_size50[19]->in[18] mux_2level_size50[19]->in[18] 0
+  0
***** Signal mux_2level_size50[19]->in[19] density = 0, probability=0.*****
Vmux_2level_size50[19]->in[19] mux_2level_size50[19]->in[19] 0
+  0
***** Signal mux_2level_size50[19]->in[20] density = 0, probability=0.*****
Vmux_2level_size50[19]->in[20] mux_2level_size50[19]->in[20] 0
+  0
***** Signal mux_2level_size50[19]->in[21] density = 0, probability=0.*****
Vmux_2level_size50[19]->in[21] mux_2level_size50[19]->in[21] 0
+  0
***** Signal mux_2level_size50[19]->in[22] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[19]->in[22] mux_2level_size50[19]->in[22] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[19]->in[23] density = 0, probability=0.*****
Vmux_2level_size50[19]->in[23] mux_2level_size50[19]->in[23] 0
+  0
***** Signal mux_2level_size50[19]->in[24] density = 0, probability=0.*****
Vmux_2level_size50[19]->in[24] mux_2level_size50[19]->in[24] 0
+  0
***** Signal mux_2level_size50[19]->in[25] density = 0, probability=0.*****
Vmux_2level_size50[19]->in[25] mux_2level_size50[19]->in[25] 0
+  0
***** Signal mux_2level_size50[19]->in[26] density = 0, probability=0.*****
Vmux_2level_size50[19]->in[26] mux_2level_size50[19]->in[26] 0
+  0
***** Signal mux_2level_size50[19]->in[27] density = 0, probability=0.*****
Vmux_2level_size50[19]->in[27] mux_2level_size50[19]->in[27] 0
+  0
***** Signal mux_2level_size50[19]->in[28] density = 0, probability=0.*****
Vmux_2level_size50[19]->in[28] mux_2level_size50[19]->in[28] 0
+  0
***** Signal mux_2level_size50[19]->in[29] density = 0, probability=0.*****
Vmux_2level_size50[19]->in[29] mux_2level_size50[19]->in[29] 0
+  0
***** Signal mux_2level_size50[19]->in[30] density = 0, probability=0.*****
Vmux_2level_size50[19]->in[30] mux_2level_size50[19]->in[30] 0
+  0
***** Signal mux_2level_size50[19]->in[31] density = 0, probability=0.*****
Vmux_2level_size50[19]->in[31] mux_2level_size50[19]->in[31] 0
+  0
***** Signal mux_2level_size50[19]->in[32] density = 0, probability=0.*****
Vmux_2level_size50[19]->in[32] mux_2level_size50[19]->in[32] 0
+  0
***** Signal mux_2level_size50[19]->in[33] density = 0, probability=0.*****
Vmux_2level_size50[19]->in[33] mux_2level_size50[19]->in[33] 0
+  0
***** Signal mux_2level_size50[19]->in[34] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[19]->in[34] mux_2level_size50[19]->in[34] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[19]->in[35] density = 0, probability=0.*****
Vmux_2level_size50[19]->in[35] mux_2level_size50[19]->in[35] 0
+  0
***** Signal mux_2level_size50[19]->in[36] density = 0, probability=0.*****
Vmux_2level_size50[19]->in[36] mux_2level_size50[19]->in[36] 0
+  0
***** Signal mux_2level_size50[19]->in[37] density = 0, probability=0.*****
Vmux_2level_size50[19]->in[37] mux_2level_size50[19]->in[37] 0
+  0
***** Signal mux_2level_size50[19]->in[38] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[19]->in[38] mux_2level_size50[19]->in[38] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[19]->in[39] density = 0, probability=0.*****
Vmux_2level_size50[19]->in[39] mux_2level_size50[19]->in[39] 0
+  0
***** Signal mux_2level_size50[19]->in[40] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[19]->in[40] mux_2level_size50[19]->in[40] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[19]->in[41] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[19]->in[41] mux_2level_size50[19]->in[41] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[19]->in[42] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[19]->in[42] mux_2level_size50[19]->in[42] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[19]->in[43] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[19]->in[43] mux_2level_size50[19]->in[43] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[19]->in[44] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[19]->in[44] mux_2level_size50[19]->in[44] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[19]->in[45] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[19]->in[45] mux_2level_size50[19]->in[45] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[19]->in[46] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[19]->in[46] mux_2level_size50[19]->in[46] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[19]->in[47] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[19]->in[47] mux_2level_size50[19]->in[47] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[19]->in[48] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[19]->in[48] mux_2level_size50[19]->in[48] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[19]->in[49] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[19]->in[49] mux_2level_size50[19]->in[49] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
Vgvdd_mux_2level_size50[19] gvdd_mux_2level_size50[19] 0 vsp
***** Measurements *****
***** Rise delay *****
.meas tran delay_rise_idle_mux50[19]_in[1]_crossbar trig v(mux_2level_size50[19]->in[0]) val='input_thres_pct_rise*vsp' rise=1 td='clock_period'
+          targ v(mux_2level_size50[19]->out) val='output_thres_pct_rise*vsp' rise=1 td='clock_period'
***** Fall delay *****
.meas tran delay_fall_idle_mux50[19]_in[1]_crossbar trig v(mux_2level_size50[19]->in[0]) val='input_thres_pct_fall*vsp' fall=1 td='clock_period'
+          targ v(mux_2level_size50[19]->out) val='output_thres_pct_fall*vsp' fall=1 td='clock_period'
***** Rise timing period *****
.meas start_rise_idle_mux50[19]_in[1]_crossbar when v(mux_2level_size50[19]->in[0])='slew_lower_thres_pct_rise*vsp' rise=1 td='clock_period'
.meas tran switch_rise_idle_mux50[19]_in[1]_crossbar trig v(mux_2level_size50[19]->in[0]) val='slew_lower_thres_pct_rise*vsp' rise=1 td='clock_period'
+          targ v(mux_2level_size50[19]->out) val='slew_upper_thres_pct_rise*vsp' rise=1 td='clock_period'
***** Fall timing period *****
.meas start_fall_idle_mux50[19]_in[1]_crossbar when v(mux_2level_size50[19]->in[0])='slew_lower_thres_pct_fall*vsp' fall=1 td='clock_period'
.meas tran switch_fall_idle_mux50[19]_in[1]_crossbar trig v(mux_2level_size50[19]->in[0]) val='slew_lower_thres_pct_fall*vsp' fall=1 td='clock_period'
+          targ v(mux_2level_size50[19]->out) val='slew_upper_thres_pct_fall*vsp' fall=1 td='clock_period'
***** Leakage Power Measurement *****
.meas tran mux_2level_size50[19]_leakage_power avg p(Vgvdd_mux_2level_size50[19]) from=0 to='clock_period'
.meas tran leakage_idle_mux50[19]_in[1]_crossbar param='mux_2level_size50[19]_leakage_power'
***** Dynamic Power Measurement *****
.meas tran mux_2level_size50[19]_dynamic_power avg p(Vgvdd_mux_2level_size50[19]) from='clock_period' to='6*clock_period'
.meas tran mux_2level_size50[19]_energy_per_cycle param='mux_2level_size50[19]_dynamic_power*clock_period'
.meas tran dynamic_power_idle_mux50[19]_in[1]_crossbar  param='mux_2level_size50[19]_dynamic_power'
.meas tran energy_per_cycle_idle_mux50[19]_in[1]_crossbar  param='dynamic_power_idle_mux50[19]_in[1]_crossbar*clock_period'
.meas tran dynamic_rise_idle_mux50[19]_in[1]_crossbar avg p(Vgvdd_mux_2level_size50[19]) from='start_rise_idle_mux50[19]_in[1]_crossbar' to='start_rise_idle_mux50[19]_in[1]_crossbar+switch_rise_idle_mux50[19]_in[1]_crossbar'
.meas tran dynamic_fall_idle_mux50[19]_in[1]_crossbar avg p(Vgvdd_mux_2level_size50[19]) from='start_fall_idle_mux50[19]_in[1]_crossbar' to='start_fall_idle_mux50[19]_in[1]_crossbar+switch_fall_idle_mux50[19]_in[1]_crossbar'
.meas tran sum_leakage_power_mux[0to19]
+          param='sum_leakage_power_mux[0to18]+leakage_idle_mux50[19]_in[1]_crossbar'
.meas tran sum_energy_per_cycle_mux[0to19]
+          param='sum_energy_per_cycle_mux[0to18]+energy_per_cycle_idle_mux50[19]_in[1]_crossbar'
Xload_inv[19]_no0 mux_2level_size50[19]->out mux_2level_size50[19]->out_out[0] gvdd_load 0 inv size=5
.meas tran sum_leakage_power_pb_mux[0to19]
+          param='sum_leakage_power_pb_mux[0to18]+leakage_idle_mux50[19]_in[1]_crossbar'
.meas tran sum_energy_per_cycle_pb_mux[0to19]
+          param='sum_energy_per_cycle_pb_mux[0to18]+energy_per_cycle_idle_mux50[19]_in[1]_crossbar'
Xmux_2level_size50[20] mux_2level_size50[20]->in[0] mux_2level_size50[20]->in[1] mux_2level_size50[20]->in[2] mux_2level_size50[20]->in[3] mux_2level_size50[20]->in[4] mux_2level_size50[20]->in[5] mux_2level_size50[20]->in[6] mux_2level_size50[20]->in[7] mux_2level_size50[20]->in[8] mux_2level_size50[20]->in[9] mux_2level_size50[20]->in[10] mux_2level_size50[20]->in[11] mux_2level_size50[20]->in[12] mux_2level_size50[20]->in[13] mux_2level_size50[20]->in[14] mux_2level_size50[20]->in[15] mux_2level_size50[20]->in[16] mux_2level_size50[20]->in[17] mux_2level_size50[20]->in[18] mux_2level_size50[20]->in[19] mux_2level_size50[20]->in[20] mux_2level_size50[20]->in[21] mux_2level_size50[20]->in[22] mux_2level_size50[20]->in[23] mux_2level_size50[20]->in[24] mux_2level_size50[20]->in[25] mux_2level_size50[20]->in[26] mux_2level_size50[20]->in[27] mux_2level_size50[20]->in[28] mux_2level_size50[20]->in[29] mux_2level_size50[20]->in[30] mux_2level_size50[20]->in[31] mux_2level_size50[20]->in[32] mux_2level_size50[20]->in[33] mux_2level_size50[20]->in[34] mux_2level_size50[20]->in[35] mux_2level_size50[20]->in[36] mux_2level_size50[20]->in[37] mux_2level_size50[20]->in[38] mux_2level_size50[20]->in[39] mux_2level_size50[20]->in[40] mux_2level_size50[20]->in[41] mux_2level_size50[20]->in[42] mux_2level_size50[20]->in[43] mux_2level_size50[20]->in[44] mux_2level_size50[20]->in[45] mux_2level_size50[20]->in[46] mux_2level_size50[20]->in[47] mux_2level_size50[20]->in[48] mux_2level_size50[20]->in[49] mux_2level_size50[20]->out sram[320]->outb sram[320]->out sram[321]->out sram[321]->outb sram[322]->out sram[322]->outb sram[323]->out sram[323]->outb sram[324]->out sram[324]->outb sram[325]->out sram[325]->outb sram[326]->out sram[326]->outb sram[327]->out sram[327]->outb sram[328]->outb sram[328]->out sram[329]->out sram[329]->outb sram[330]->out sram[330]->outb sram[331]->out sram[331]->outb sram[332]->out sram[332]->outb sram[333]->out sram[333]->outb sram[334]->out sram[334]->outb sram[335]->out sram[335]->outb gvdd_mux_2level_size50[20] 0 mux_2level_size50
***** SRAM bits for MUX[20], level=2, select_path_id=0. *****
*****1000000010000000*****
Xsram[320] sram->in sram[320]->out sram[320]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[320]->out) 0
.nodeset V(sram[320]->outb) vsp
Xsram[321] sram->in sram[321]->out sram[321]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[321]->out) 0
.nodeset V(sram[321]->outb) vsp
Xsram[322] sram->in sram[322]->out sram[322]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[322]->out) 0
.nodeset V(sram[322]->outb) vsp
Xsram[323] sram->in sram[323]->out sram[323]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[323]->out) 0
.nodeset V(sram[323]->outb) vsp
Xsram[324] sram->in sram[324]->out sram[324]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[324]->out) 0
.nodeset V(sram[324]->outb) vsp
Xsram[325] sram->in sram[325]->out sram[325]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[325]->out) 0
.nodeset V(sram[325]->outb) vsp
Xsram[326] sram->in sram[326]->out sram[326]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[326]->out) 0
.nodeset V(sram[326]->outb) vsp
Xsram[327] sram->in sram[327]->out sram[327]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[327]->out) 0
.nodeset V(sram[327]->outb) vsp
Xsram[328] sram->in sram[328]->out sram[328]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[328]->out) 0
.nodeset V(sram[328]->outb) vsp
Xsram[329] sram->in sram[329]->out sram[329]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[329]->out) 0
.nodeset V(sram[329]->outb) vsp
Xsram[330] sram->in sram[330]->out sram[330]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[330]->out) 0
.nodeset V(sram[330]->outb) vsp
Xsram[331] sram->in sram[331]->out sram[331]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[331]->out) 0
.nodeset V(sram[331]->outb) vsp
Xsram[332] sram->in sram[332]->out sram[332]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[332]->out) 0
.nodeset V(sram[332]->outb) vsp
Xsram[333] sram->in sram[333]->out sram[333]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[333]->out) 0
.nodeset V(sram[333]->outb) vsp
Xsram[334] sram->in sram[334]->out sram[334]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[334]->out) 0
.nodeset V(sram[334]->outb) vsp
Xsram[335] sram->in sram[335]->out sram[335]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[335]->out) 0
.nodeset V(sram[335]->outb) vsp
***** Signal mux_2level_size50[20]->in[0] density = 0, probability=0.*****
Vmux_2level_size50[20]->in[0] mux_2level_size50[20]->in[0] 0
+  0
***** Signal mux_2level_size50[20]->in[1] density = 0, probability=0.*****
Vmux_2level_size50[20]->in[1] mux_2level_size50[20]->in[1] 0
+  0
***** Signal mux_2level_size50[20]->in[2] density = 0, probability=0.*****
Vmux_2level_size50[20]->in[2] mux_2level_size50[20]->in[2] 0
+  0
***** Signal mux_2level_size50[20]->in[3] density = 0, probability=0.*****
Vmux_2level_size50[20]->in[3] mux_2level_size50[20]->in[3] 0
+  0
***** Signal mux_2level_size50[20]->in[4] density = 0, probability=0.*****
Vmux_2level_size50[20]->in[4] mux_2level_size50[20]->in[4] 0
+  0
***** Signal mux_2level_size50[20]->in[5] density = 0, probability=0.*****
Vmux_2level_size50[20]->in[5] mux_2level_size50[20]->in[5] 0
+  0
***** Signal mux_2level_size50[20]->in[6] density = 0, probability=0.*****
Vmux_2level_size50[20]->in[6] mux_2level_size50[20]->in[6] 0
+  0
***** Signal mux_2level_size50[20]->in[7] density = 0, probability=0.*****
Vmux_2level_size50[20]->in[7] mux_2level_size50[20]->in[7] 0
+  0
***** Signal mux_2level_size50[20]->in[8] density = 0, probability=0.*****
Vmux_2level_size50[20]->in[8] mux_2level_size50[20]->in[8] 0
+  0
***** Signal mux_2level_size50[20]->in[9] density = 0, probability=0.*****
Vmux_2level_size50[20]->in[9] mux_2level_size50[20]->in[9] 0
+  0
***** Signal mux_2level_size50[20]->in[10] density = 0, probability=0.*****
Vmux_2level_size50[20]->in[10] mux_2level_size50[20]->in[10] 0
+  0
***** Signal mux_2level_size50[20]->in[11] density = 0, probability=0.*****
Vmux_2level_size50[20]->in[11] mux_2level_size50[20]->in[11] 0
+  0
***** Signal mux_2level_size50[20]->in[12] density = 0, probability=0.*****
Vmux_2level_size50[20]->in[12] mux_2level_size50[20]->in[12] 0
+  0
***** Signal mux_2level_size50[20]->in[13] density = 0, probability=0.*****
Vmux_2level_size50[20]->in[13] mux_2level_size50[20]->in[13] 0
+  0
***** Signal mux_2level_size50[20]->in[14] density = 0, probability=0.*****
Vmux_2level_size50[20]->in[14] mux_2level_size50[20]->in[14] 0
+  0
***** Signal mux_2level_size50[20]->in[15] density = 0, probability=0.*****
Vmux_2level_size50[20]->in[15] mux_2level_size50[20]->in[15] 0
+  0
***** Signal mux_2level_size50[20]->in[16] density = 0, probability=0.*****
Vmux_2level_size50[20]->in[16] mux_2level_size50[20]->in[16] 0
+  0
***** Signal mux_2level_size50[20]->in[17] density = 0, probability=0.*****
Vmux_2level_size50[20]->in[17] mux_2level_size50[20]->in[17] 0
+  0
***** Signal mux_2level_size50[20]->in[18] density = 0, probability=0.*****
Vmux_2level_size50[20]->in[18] mux_2level_size50[20]->in[18] 0
+  0
***** Signal mux_2level_size50[20]->in[19] density = 0, probability=0.*****
Vmux_2level_size50[20]->in[19] mux_2level_size50[20]->in[19] 0
+  0
***** Signal mux_2level_size50[20]->in[20] density = 0, probability=0.*****
Vmux_2level_size50[20]->in[20] mux_2level_size50[20]->in[20] 0
+  0
***** Signal mux_2level_size50[20]->in[21] density = 0, probability=0.*****
Vmux_2level_size50[20]->in[21] mux_2level_size50[20]->in[21] 0
+  0
***** Signal mux_2level_size50[20]->in[22] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[20]->in[22] mux_2level_size50[20]->in[22] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[20]->in[23] density = 0, probability=0.*****
Vmux_2level_size50[20]->in[23] mux_2level_size50[20]->in[23] 0
+  0
***** Signal mux_2level_size50[20]->in[24] density = 0, probability=0.*****
Vmux_2level_size50[20]->in[24] mux_2level_size50[20]->in[24] 0
+  0
***** Signal mux_2level_size50[20]->in[25] density = 0, probability=0.*****
Vmux_2level_size50[20]->in[25] mux_2level_size50[20]->in[25] 0
+  0
***** Signal mux_2level_size50[20]->in[26] density = 0, probability=0.*****
Vmux_2level_size50[20]->in[26] mux_2level_size50[20]->in[26] 0
+  0
***** Signal mux_2level_size50[20]->in[27] density = 0, probability=0.*****
Vmux_2level_size50[20]->in[27] mux_2level_size50[20]->in[27] 0
+  0
***** Signal mux_2level_size50[20]->in[28] density = 0, probability=0.*****
Vmux_2level_size50[20]->in[28] mux_2level_size50[20]->in[28] 0
+  0
***** Signal mux_2level_size50[20]->in[29] density = 0, probability=0.*****
Vmux_2level_size50[20]->in[29] mux_2level_size50[20]->in[29] 0
+  0
***** Signal mux_2level_size50[20]->in[30] density = 0, probability=0.*****
Vmux_2level_size50[20]->in[30] mux_2level_size50[20]->in[30] 0
+  0
***** Signal mux_2level_size50[20]->in[31] density = 0, probability=0.*****
Vmux_2level_size50[20]->in[31] mux_2level_size50[20]->in[31] 0
+  0
***** Signal mux_2level_size50[20]->in[32] density = 0, probability=0.*****
Vmux_2level_size50[20]->in[32] mux_2level_size50[20]->in[32] 0
+  0
***** Signal mux_2level_size50[20]->in[33] density = 0, probability=0.*****
Vmux_2level_size50[20]->in[33] mux_2level_size50[20]->in[33] 0
+  0
***** Signal mux_2level_size50[20]->in[34] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[20]->in[34] mux_2level_size50[20]->in[34] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[20]->in[35] density = 0, probability=0.*****
Vmux_2level_size50[20]->in[35] mux_2level_size50[20]->in[35] 0
+  0
***** Signal mux_2level_size50[20]->in[36] density = 0, probability=0.*****
Vmux_2level_size50[20]->in[36] mux_2level_size50[20]->in[36] 0
+  0
***** Signal mux_2level_size50[20]->in[37] density = 0, probability=0.*****
Vmux_2level_size50[20]->in[37] mux_2level_size50[20]->in[37] 0
+  0
***** Signal mux_2level_size50[20]->in[38] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[20]->in[38] mux_2level_size50[20]->in[38] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[20]->in[39] density = 0, probability=0.*****
Vmux_2level_size50[20]->in[39] mux_2level_size50[20]->in[39] 0
+  0
***** Signal mux_2level_size50[20]->in[40] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[20]->in[40] mux_2level_size50[20]->in[40] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[20]->in[41] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[20]->in[41] mux_2level_size50[20]->in[41] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[20]->in[42] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[20]->in[42] mux_2level_size50[20]->in[42] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[20]->in[43] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[20]->in[43] mux_2level_size50[20]->in[43] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[20]->in[44] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[20]->in[44] mux_2level_size50[20]->in[44] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[20]->in[45] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[20]->in[45] mux_2level_size50[20]->in[45] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[20]->in[46] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[20]->in[46] mux_2level_size50[20]->in[46] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[20]->in[47] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[20]->in[47] mux_2level_size50[20]->in[47] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[20]->in[48] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[20]->in[48] mux_2level_size50[20]->in[48] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[20]->in[49] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[20]->in[49] mux_2level_size50[20]->in[49] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
Vgvdd_mux_2level_size50[20] gvdd_mux_2level_size50[20] 0 vsp
***** Measurements *****
***** Rise delay *****
.meas tran delay_rise_idle_mux50[20]_in[2]_crossbar trig v(mux_2level_size50[20]->in[0]) val='input_thres_pct_rise*vsp' rise=1 td='clock_period'
+          targ v(mux_2level_size50[20]->out) val='output_thres_pct_rise*vsp' rise=1 td='clock_period'
***** Fall delay *****
.meas tran delay_fall_idle_mux50[20]_in[2]_crossbar trig v(mux_2level_size50[20]->in[0]) val='input_thres_pct_fall*vsp' fall=1 td='clock_period'
+          targ v(mux_2level_size50[20]->out) val='output_thres_pct_fall*vsp' fall=1 td='clock_period'
***** Rise timing period *****
.meas start_rise_idle_mux50[20]_in[2]_crossbar when v(mux_2level_size50[20]->in[0])='slew_lower_thres_pct_rise*vsp' rise=1 td='clock_period'
.meas tran switch_rise_idle_mux50[20]_in[2]_crossbar trig v(mux_2level_size50[20]->in[0]) val='slew_lower_thres_pct_rise*vsp' rise=1 td='clock_period'
+          targ v(mux_2level_size50[20]->out) val='slew_upper_thres_pct_rise*vsp' rise=1 td='clock_period'
***** Fall timing period *****
.meas start_fall_idle_mux50[20]_in[2]_crossbar when v(mux_2level_size50[20]->in[0])='slew_lower_thres_pct_fall*vsp' fall=1 td='clock_period'
.meas tran switch_fall_idle_mux50[20]_in[2]_crossbar trig v(mux_2level_size50[20]->in[0]) val='slew_lower_thres_pct_fall*vsp' fall=1 td='clock_period'
+          targ v(mux_2level_size50[20]->out) val='slew_upper_thres_pct_fall*vsp' fall=1 td='clock_period'
***** Leakage Power Measurement *****
.meas tran mux_2level_size50[20]_leakage_power avg p(Vgvdd_mux_2level_size50[20]) from=0 to='clock_period'
.meas tran leakage_idle_mux50[20]_in[2]_crossbar param='mux_2level_size50[20]_leakage_power'
***** Dynamic Power Measurement *****
.meas tran mux_2level_size50[20]_dynamic_power avg p(Vgvdd_mux_2level_size50[20]) from='clock_period' to='6*clock_period'
.meas tran mux_2level_size50[20]_energy_per_cycle param='mux_2level_size50[20]_dynamic_power*clock_period'
.meas tran dynamic_power_idle_mux50[20]_in[2]_crossbar  param='mux_2level_size50[20]_dynamic_power'
.meas tran energy_per_cycle_idle_mux50[20]_in[2]_crossbar  param='dynamic_power_idle_mux50[20]_in[2]_crossbar*clock_period'
.meas tran dynamic_rise_idle_mux50[20]_in[2]_crossbar avg p(Vgvdd_mux_2level_size50[20]) from='start_rise_idle_mux50[20]_in[2]_crossbar' to='start_rise_idle_mux50[20]_in[2]_crossbar+switch_rise_idle_mux50[20]_in[2]_crossbar'
.meas tran dynamic_fall_idle_mux50[20]_in[2]_crossbar avg p(Vgvdd_mux_2level_size50[20]) from='start_fall_idle_mux50[20]_in[2]_crossbar' to='start_fall_idle_mux50[20]_in[2]_crossbar+switch_fall_idle_mux50[20]_in[2]_crossbar'
.meas tran sum_leakage_power_mux[0to20]
+          param='sum_leakage_power_mux[0to19]+leakage_idle_mux50[20]_in[2]_crossbar'
.meas tran sum_energy_per_cycle_mux[0to20]
+          param='sum_energy_per_cycle_mux[0to19]+energy_per_cycle_idle_mux50[20]_in[2]_crossbar'
Xload_inv[20]_no0 mux_2level_size50[20]->out mux_2level_size50[20]->out_out[0] gvdd_load 0 inv size=5
.meas tran sum_leakage_power_pb_mux[0to20]
+          param='sum_leakage_power_pb_mux[0to19]+leakage_idle_mux50[20]_in[2]_crossbar'
.meas tran sum_energy_per_cycle_pb_mux[0to20]
+          param='sum_energy_per_cycle_pb_mux[0to19]+energy_per_cycle_idle_mux50[20]_in[2]_crossbar'
Xmux_2level_size50[21] mux_2level_size50[21]->in[0] mux_2level_size50[21]->in[1] mux_2level_size50[21]->in[2] mux_2level_size50[21]->in[3] mux_2level_size50[21]->in[4] mux_2level_size50[21]->in[5] mux_2level_size50[21]->in[6] mux_2level_size50[21]->in[7] mux_2level_size50[21]->in[8] mux_2level_size50[21]->in[9] mux_2level_size50[21]->in[10] mux_2level_size50[21]->in[11] mux_2level_size50[21]->in[12] mux_2level_size50[21]->in[13] mux_2level_size50[21]->in[14] mux_2level_size50[21]->in[15] mux_2level_size50[21]->in[16] mux_2level_size50[21]->in[17] mux_2level_size50[21]->in[18] mux_2level_size50[21]->in[19] mux_2level_size50[21]->in[20] mux_2level_size50[21]->in[21] mux_2level_size50[21]->in[22] mux_2level_size50[21]->in[23] mux_2level_size50[21]->in[24] mux_2level_size50[21]->in[25] mux_2level_size50[21]->in[26] mux_2level_size50[21]->in[27] mux_2level_size50[21]->in[28] mux_2level_size50[21]->in[29] mux_2level_size50[21]->in[30] mux_2level_size50[21]->in[31] mux_2level_size50[21]->in[32] mux_2level_size50[21]->in[33] mux_2level_size50[21]->in[34] mux_2level_size50[21]->in[35] mux_2level_size50[21]->in[36] mux_2level_size50[21]->in[37] mux_2level_size50[21]->in[38] mux_2level_size50[21]->in[39] mux_2level_size50[21]->in[40] mux_2level_size50[21]->in[41] mux_2level_size50[21]->in[42] mux_2level_size50[21]->in[43] mux_2level_size50[21]->in[44] mux_2level_size50[21]->in[45] mux_2level_size50[21]->in[46] mux_2level_size50[21]->in[47] mux_2level_size50[21]->in[48] mux_2level_size50[21]->in[49] mux_2level_size50[21]->out sram[336]->outb sram[336]->out sram[337]->out sram[337]->outb sram[338]->out sram[338]->outb sram[339]->out sram[339]->outb sram[340]->out sram[340]->outb sram[341]->out sram[341]->outb sram[342]->out sram[342]->outb sram[343]->out sram[343]->outb sram[344]->outb sram[344]->out sram[345]->out sram[345]->outb sram[346]->out sram[346]->outb sram[347]->out sram[347]->outb sram[348]->out sram[348]->outb sram[349]->out sram[349]->outb sram[350]->out sram[350]->outb sram[351]->out sram[351]->outb gvdd_mux_2level_size50[21] 0 mux_2level_size50
***** SRAM bits for MUX[21], level=2, select_path_id=0. *****
*****1000000010000000*****
Xsram[336] sram->in sram[336]->out sram[336]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[336]->out) 0
.nodeset V(sram[336]->outb) vsp
Xsram[337] sram->in sram[337]->out sram[337]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[337]->out) 0
.nodeset V(sram[337]->outb) vsp
Xsram[338] sram->in sram[338]->out sram[338]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[338]->out) 0
.nodeset V(sram[338]->outb) vsp
Xsram[339] sram->in sram[339]->out sram[339]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[339]->out) 0
.nodeset V(sram[339]->outb) vsp
Xsram[340] sram->in sram[340]->out sram[340]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[340]->out) 0
.nodeset V(sram[340]->outb) vsp
Xsram[341] sram->in sram[341]->out sram[341]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[341]->out) 0
.nodeset V(sram[341]->outb) vsp
Xsram[342] sram->in sram[342]->out sram[342]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[342]->out) 0
.nodeset V(sram[342]->outb) vsp
Xsram[343] sram->in sram[343]->out sram[343]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[343]->out) 0
.nodeset V(sram[343]->outb) vsp
Xsram[344] sram->in sram[344]->out sram[344]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[344]->out) 0
.nodeset V(sram[344]->outb) vsp
Xsram[345] sram->in sram[345]->out sram[345]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[345]->out) 0
.nodeset V(sram[345]->outb) vsp
Xsram[346] sram->in sram[346]->out sram[346]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[346]->out) 0
.nodeset V(sram[346]->outb) vsp
Xsram[347] sram->in sram[347]->out sram[347]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[347]->out) 0
.nodeset V(sram[347]->outb) vsp
Xsram[348] sram->in sram[348]->out sram[348]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[348]->out) 0
.nodeset V(sram[348]->outb) vsp
Xsram[349] sram->in sram[349]->out sram[349]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[349]->out) 0
.nodeset V(sram[349]->outb) vsp
Xsram[350] sram->in sram[350]->out sram[350]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[350]->out) 0
.nodeset V(sram[350]->outb) vsp
Xsram[351] sram->in sram[351]->out sram[351]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[351]->out) 0
.nodeset V(sram[351]->outb) vsp
***** Signal mux_2level_size50[21]->in[0] density = 0, probability=0.*****
Vmux_2level_size50[21]->in[0] mux_2level_size50[21]->in[0] 0
+  0
***** Signal mux_2level_size50[21]->in[1] density = 0, probability=0.*****
Vmux_2level_size50[21]->in[1] mux_2level_size50[21]->in[1] 0
+  0
***** Signal mux_2level_size50[21]->in[2] density = 0, probability=0.*****
Vmux_2level_size50[21]->in[2] mux_2level_size50[21]->in[2] 0
+  0
***** Signal mux_2level_size50[21]->in[3] density = 0, probability=0.*****
Vmux_2level_size50[21]->in[3] mux_2level_size50[21]->in[3] 0
+  0
***** Signal mux_2level_size50[21]->in[4] density = 0, probability=0.*****
Vmux_2level_size50[21]->in[4] mux_2level_size50[21]->in[4] 0
+  0
***** Signal mux_2level_size50[21]->in[5] density = 0, probability=0.*****
Vmux_2level_size50[21]->in[5] mux_2level_size50[21]->in[5] 0
+  0
***** Signal mux_2level_size50[21]->in[6] density = 0, probability=0.*****
Vmux_2level_size50[21]->in[6] mux_2level_size50[21]->in[6] 0
+  0
***** Signal mux_2level_size50[21]->in[7] density = 0, probability=0.*****
Vmux_2level_size50[21]->in[7] mux_2level_size50[21]->in[7] 0
+  0
***** Signal mux_2level_size50[21]->in[8] density = 0, probability=0.*****
Vmux_2level_size50[21]->in[8] mux_2level_size50[21]->in[8] 0
+  0
***** Signal mux_2level_size50[21]->in[9] density = 0, probability=0.*****
Vmux_2level_size50[21]->in[9] mux_2level_size50[21]->in[9] 0
+  0
***** Signal mux_2level_size50[21]->in[10] density = 0, probability=0.*****
Vmux_2level_size50[21]->in[10] mux_2level_size50[21]->in[10] 0
+  0
***** Signal mux_2level_size50[21]->in[11] density = 0, probability=0.*****
Vmux_2level_size50[21]->in[11] mux_2level_size50[21]->in[11] 0
+  0
***** Signal mux_2level_size50[21]->in[12] density = 0, probability=0.*****
Vmux_2level_size50[21]->in[12] mux_2level_size50[21]->in[12] 0
+  0
***** Signal mux_2level_size50[21]->in[13] density = 0, probability=0.*****
Vmux_2level_size50[21]->in[13] mux_2level_size50[21]->in[13] 0
+  0
***** Signal mux_2level_size50[21]->in[14] density = 0, probability=0.*****
Vmux_2level_size50[21]->in[14] mux_2level_size50[21]->in[14] 0
+  0
***** Signal mux_2level_size50[21]->in[15] density = 0, probability=0.*****
Vmux_2level_size50[21]->in[15] mux_2level_size50[21]->in[15] 0
+  0
***** Signal mux_2level_size50[21]->in[16] density = 0, probability=0.*****
Vmux_2level_size50[21]->in[16] mux_2level_size50[21]->in[16] 0
+  0
***** Signal mux_2level_size50[21]->in[17] density = 0, probability=0.*****
Vmux_2level_size50[21]->in[17] mux_2level_size50[21]->in[17] 0
+  0
***** Signal mux_2level_size50[21]->in[18] density = 0, probability=0.*****
Vmux_2level_size50[21]->in[18] mux_2level_size50[21]->in[18] 0
+  0
***** Signal mux_2level_size50[21]->in[19] density = 0, probability=0.*****
Vmux_2level_size50[21]->in[19] mux_2level_size50[21]->in[19] 0
+  0
***** Signal mux_2level_size50[21]->in[20] density = 0, probability=0.*****
Vmux_2level_size50[21]->in[20] mux_2level_size50[21]->in[20] 0
+  0
***** Signal mux_2level_size50[21]->in[21] density = 0, probability=0.*****
Vmux_2level_size50[21]->in[21] mux_2level_size50[21]->in[21] 0
+  0
***** Signal mux_2level_size50[21]->in[22] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[21]->in[22] mux_2level_size50[21]->in[22] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[21]->in[23] density = 0, probability=0.*****
Vmux_2level_size50[21]->in[23] mux_2level_size50[21]->in[23] 0
+  0
***** Signal mux_2level_size50[21]->in[24] density = 0, probability=0.*****
Vmux_2level_size50[21]->in[24] mux_2level_size50[21]->in[24] 0
+  0
***** Signal mux_2level_size50[21]->in[25] density = 0, probability=0.*****
Vmux_2level_size50[21]->in[25] mux_2level_size50[21]->in[25] 0
+  0
***** Signal mux_2level_size50[21]->in[26] density = 0, probability=0.*****
Vmux_2level_size50[21]->in[26] mux_2level_size50[21]->in[26] 0
+  0
***** Signal mux_2level_size50[21]->in[27] density = 0, probability=0.*****
Vmux_2level_size50[21]->in[27] mux_2level_size50[21]->in[27] 0
+  0
***** Signal mux_2level_size50[21]->in[28] density = 0, probability=0.*****
Vmux_2level_size50[21]->in[28] mux_2level_size50[21]->in[28] 0
+  0
***** Signal mux_2level_size50[21]->in[29] density = 0, probability=0.*****
Vmux_2level_size50[21]->in[29] mux_2level_size50[21]->in[29] 0
+  0
***** Signal mux_2level_size50[21]->in[30] density = 0, probability=0.*****
Vmux_2level_size50[21]->in[30] mux_2level_size50[21]->in[30] 0
+  0
***** Signal mux_2level_size50[21]->in[31] density = 0, probability=0.*****
Vmux_2level_size50[21]->in[31] mux_2level_size50[21]->in[31] 0
+  0
***** Signal mux_2level_size50[21]->in[32] density = 0, probability=0.*****
Vmux_2level_size50[21]->in[32] mux_2level_size50[21]->in[32] 0
+  0
***** Signal mux_2level_size50[21]->in[33] density = 0, probability=0.*****
Vmux_2level_size50[21]->in[33] mux_2level_size50[21]->in[33] 0
+  0
***** Signal mux_2level_size50[21]->in[34] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[21]->in[34] mux_2level_size50[21]->in[34] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[21]->in[35] density = 0, probability=0.*****
Vmux_2level_size50[21]->in[35] mux_2level_size50[21]->in[35] 0
+  0
***** Signal mux_2level_size50[21]->in[36] density = 0, probability=0.*****
Vmux_2level_size50[21]->in[36] mux_2level_size50[21]->in[36] 0
+  0
***** Signal mux_2level_size50[21]->in[37] density = 0, probability=0.*****
Vmux_2level_size50[21]->in[37] mux_2level_size50[21]->in[37] 0
+  0
***** Signal mux_2level_size50[21]->in[38] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[21]->in[38] mux_2level_size50[21]->in[38] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[21]->in[39] density = 0, probability=0.*****
Vmux_2level_size50[21]->in[39] mux_2level_size50[21]->in[39] 0
+  0
***** Signal mux_2level_size50[21]->in[40] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[21]->in[40] mux_2level_size50[21]->in[40] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[21]->in[41] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[21]->in[41] mux_2level_size50[21]->in[41] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[21]->in[42] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[21]->in[42] mux_2level_size50[21]->in[42] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[21]->in[43] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[21]->in[43] mux_2level_size50[21]->in[43] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[21]->in[44] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[21]->in[44] mux_2level_size50[21]->in[44] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[21]->in[45] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[21]->in[45] mux_2level_size50[21]->in[45] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[21]->in[46] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[21]->in[46] mux_2level_size50[21]->in[46] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[21]->in[47] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[21]->in[47] mux_2level_size50[21]->in[47] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[21]->in[48] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[21]->in[48] mux_2level_size50[21]->in[48] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[21]->in[49] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[21]->in[49] mux_2level_size50[21]->in[49] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
Vgvdd_mux_2level_size50[21] gvdd_mux_2level_size50[21] 0 vsp
***** Measurements *****
***** Rise delay *****
.meas tran delay_rise_idle_mux50[21]_in[3]_crossbar trig v(mux_2level_size50[21]->in[0]) val='input_thres_pct_rise*vsp' rise=1 td='clock_period'
+          targ v(mux_2level_size50[21]->out) val='output_thres_pct_rise*vsp' rise=1 td='clock_period'
***** Fall delay *****
.meas tran delay_fall_idle_mux50[21]_in[3]_crossbar trig v(mux_2level_size50[21]->in[0]) val='input_thres_pct_fall*vsp' fall=1 td='clock_period'
+          targ v(mux_2level_size50[21]->out) val='output_thres_pct_fall*vsp' fall=1 td='clock_period'
***** Rise timing period *****
.meas start_rise_idle_mux50[21]_in[3]_crossbar when v(mux_2level_size50[21]->in[0])='slew_lower_thres_pct_rise*vsp' rise=1 td='clock_period'
.meas tran switch_rise_idle_mux50[21]_in[3]_crossbar trig v(mux_2level_size50[21]->in[0]) val='slew_lower_thres_pct_rise*vsp' rise=1 td='clock_period'
+          targ v(mux_2level_size50[21]->out) val='slew_upper_thres_pct_rise*vsp' rise=1 td='clock_period'
***** Fall timing period *****
.meas start_fall_idle_mux50[21]_in[3]_crossbar when v(mux_2level_size50[21]->in[0])='slew_lower_thres_pct_fall*vsp' fall=1 td='clock_period'
.meas tran switch_fall_idle_mux50[21]_in[3]_crossbar trig v(mux_2level_size50[21]->in[0]) val='slew_lower_thres_pct_fall*vsp' fall=1 td='clock_period'
+          targ v(mux_2level_size50[21]->out) val='slew_upper_thres_pct_fall*vsp' fall=1 td='clock_period'
***** Leakage Power Measurement *****
.meas tran mux_2level_size50[21]_leakage_power avg p(Vgvdd_mux_2level_size50[21]) from=0 to='clock_period'
.meas tran leakage_idle_mux50[21]_in[3]_crossbar param='mux_2level_size50[21]_leakage_power'
***** Dynamic Power Measurement *****
.meas tran mux_2level_size50[21]_dynamic_power avg p(Vgvdd_mux_2level_size50[21]) from='clock_period' to='6*clock_period'
.meas tran mux_2level_size50[21]_energy_per_cycle param='mux_2level_size50[21]_dynamic_power*clock_period'
.meas tran dynamic_power_idle_mux50[21]_in[3]_crossbar  param='mux_2level_size50[21]_dynamic_power'
.meas tran energy_per_cycle_idle_mux50[21]_in[3]_crossbar  param='dynamic_power_idle_mux50[21]_in[3]_crossbar*clock_period'
.meas tran dynamic_rise_idle_mux50[21]_in[3]_crossbar avg p(Vgvdd_mux_2level_size50[21]) from='start_rise_idle_mux50[21]_in[3]_crossbar' to='start_rise_idle_mux50[21]_in[3]_crossbar+switch_rise_idle_mux50[21]_in[3]_crossbar'
.meas tran dynamic_fall_idle_mux50[21]_in[3]_crossbar avg p(Vgvdd_mux_2level_size50[21]) from='start_fall_idle_mux50[21]_in[3]_crossbar' to='start_fall_idle_mux50[21]_in[3]_crossbar+switch_fall_idle_mux50[21]_in[3]_crossbar'
.meas tran sum_leakage_power_mux[0to21]
+          param='sum_leakage_power_mux[0to20]+leakage_idle_mux50[21]_in[3]_crossbar'
.meas tran sum_energy_per_cycle_mux[0to21]
+          param='sum_energy_per_cycle_mux[0to20]+energy_per_cycle_idle_mux50[21]_in[3]_crossbar'
Xload_inv[21]_no0 mux_2level_size50[21]->out mux_2level_size50[21]->out_out[0] gvdd_load 0 inv size=5
.meas tran sum_leakage_power_pb_mux[0to21]
+          param='sum_leakage_power_pb_mux[0to20]+leakage_idle_mux50[21]_in[3]_crossbar'
.meas tran sum_energy_per_cycle_pb_mux[0to21]
+          param='sum_energy_per_cycle_pb_mux[0to20]+energy_per_cycle_idle_mux50[21]_in[3]_crossbar'
Xmux_2level_size50[22] mux_2level_size50[22]->in[0] mux_2level_size50[22]->in[1] mux_2level_size50[22]->in[2] mux_2level_size50[22]->in[3] mux_2level_size50[22]->in[4] mux_2level_size50[22]->in[5] mux_2level_size50[22]->in[6] mux_2level_size50[22]->in[7] mux_2level_size50[22]->in[8] mux_2level_size50[22]->in[9] mux_2level_size50[22]->in[10] mux_2level_size50[22]->in[11] mux_2level_size50[22]->in[12] mux_2level_size50[22]->in[13] mux_2level_size50[22]->in[14] mux_2level_size50[22]->in[15] mux_2level_size50[22]->in[16] mux_2level_size50[22]->in[17] mux_2level_size50[22]->in[18] mux_2level_size50[22]->in[19] mux_2level_size50[22]->in[20] mux_2level_size50[22]->in[21] mux_2level_size50[22]->in[22] mux_2level_size50[22]->in[23] mux_2level_size50[22]->in[24] mux_2level_size50[22]->in[25] mux_2level_size50[22]->in[26] mux_2level_size50[22]->in[27] mux_2level_size50[22]->in[28] mux_2level_size50[22]->in[29] mux_2level_size50[22]->in[30] mux_2level_size50[22]->in[31] mux_2level_size50[22]->in[32] mux_2level_size50[22]->in[33] mux_2level_size50[22]->in[34] mux_2level_size50[22]->in[35] mux_2level_size50[22]->in[36] mux_2level_size50[22]->in[37] mux_2level_size50[22]->in[38] mux_2level_size50[22]->in[39] mux_2level_size50[22]->in[40] mux_2level_size50[22]->in[41] mux_2level_size50[22]->in[42] mux_2level_size50[22]->in[43] mux_2level_size50[22]->in[44] mux_2level_size50[22]->in[45] mux_2level_size50[22]->in[46] mux_2level_size50[22]->in[47] mux_2level_size50[22]->in[48] mux_2level_size50[22]->in[49] mux_2level_size50[22]->out sram[352]->outb sram[352]->out sram[353]->out sram[353]->outb sram[354]->out sram[354]->outb sram[355]->out sram[355]->outb sram[356]->out sram[356]->outb sram[357]->out sram[357]->outb sram[358]->out sram[358]->outb sram[359]->out sram[359]->outb sram[360]->outb sram[360]->out sram[361]->out sram[361]->outb sram[362]->out sram[362]->outb sram[363]->out sram[363]->outb sram[364]->out sram[364]->outb sram[365]->out sram[365]->outb sram[366]->out sram[366]->outb sram[367]->out sram[367]->outb gvdd_mux_2level_size50[22] 0 mux_2level_size50
***** SRAM bits for MUX[22], level=2, select_path_id=0. *****
*****1000000010000000*****
Xsram[352] sram->in sram[352]->out sram[352]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[352]->out) 0
.nodeset V(sram[352]->outb) vsp
Xsram[353] sram->in sram[353]->out sram[353]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[353]->out) 0
.nodeset V(sram[353]->outb) vsp
Xsram[354] sram->in sram[354]->out sram[354]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[354]->out) 0
.nodeset V(sram[354]->outb) vsp
Xsram[355] sram->in sram[355]->out sram[355]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[355]->out) 0
.nodeset V(sram[355]->outb) vsp
Xsram[356] sram->in sram[356]->out sram[356]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[356]->out) 0
.nodeset V(sram[356]->outb) vsp
Xsram[357] sram->in sram[357]->out sram[357]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[357]->out) 0
.nodeset V(sram[357]->outb) vsp
Xsram[358] sram->in sram[358]->out sram[358]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[358]->out) 0
.nodeset V(sram[358]->outb) vsp
Xsram[359] sram->in sram[359]->out sram[359]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[359]->out) 0
.nodeset V(sram[359]->outb) vsp
Xsram[360] sram->in sram[360]->out sram[360]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[360]->out) 0
.nodeset V(sram[360]->outb) vsp
Xsram[361] sram->in sram[361]->out sram[361]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[361]->out) 0
.nodeset V(sram[361]->outb) vsp
Xsram[362] sram->in sram[362]->out sram[362]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[362]->out) 0
.nodeset V(sram[362]->outb) vsp
Xsram[363] sram->in sram[363]->out sram[363]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[363]->out) 0
.nodeset V(sram[363]->outb) vsp
Xsram[364] sram->in sram[364]->out sram[364]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[364]->out) 0
.nodeset V(sram[364]->outb) vsp
Xsram[365] sram->in sram[365]->out sram[365]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[365]->out) 0
.nodeset V(sram[365]->outb) vsp
Xsram[366] sram->in sram[366]->out sram[366]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[366]->out) 0
.nodeset V(sram[366]->outb) vsp
Xsram[367] sram->in sram[367]->out sram[367]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[367]->out) 0
.nodeset V(sram[367]->outb) vsp
***** Signal mux_2level_size50[22]->in[0] density = 0, probability=0.*****
Vmux_2level_size50[22]->in[0] mux_2level_size50[22]->in[0] 0
+  0
***** Signal mux_2level_size50[22]->in[1] density = 0, probability=0.*****
Vmux_2level_size50[22]->in[1] mux_2level_size50[22]->in[1] 0
+  0
***** Signal mux_2level_size50[22]->in[2] density = 0, probability=0.*****
Vmux_2level_size50[22]->in[2] mux_2level_size50[22]->in[2] 0
+  0
***** Signal mux_2level_size50[22]->in[3] density = 0, probability=0.*****
Vmux_2level_size50[22]->in[3] mux_2level_size50[22]->in[3] 0
+  0
***** Signal mux_2level_size50[22]->in[4] density = 0, probability=0.*****
Vmux_2level_size50[22]->in[4] mux_2level_size50[22]->in[4] 0
+  0
***** Signal mux_2level_size50[22]->in[5] density = 0, probability=0.*****
Vmux_2level_size50[22]->in[5] mux_2level_size50[22]->in[5] 0
+  0
***** Signal mux_2level_size50[22]->in[6] density = 0, probability=0.*****
Vmux_2level_size50[22]->in[6] mux_2level_size50[22]->in[6] 0
+  0
***** Signal mux_2level_size50[22]->in[7] density = 0, probability=0.*****
Vmux_2level_size50[22]->in[7] mux_2level_size50[22]->in[7] 0
+  0
***** Signal mux_2level_size50[22]->in[8] density = 0, probability=0.*****
Vmux_2level_size50[22]->in[8] mux_2level_size50[22]->in[8] 0
+  0
***** Signal mux_2level_size50[22]->in[9] density = 0, probability=0.*****
Vmux_2level_size50[22]->in[9] mux_2level_size50[22]->in[9] 0
+  0
***** Signal mux_2level_size50[22]->in[10] density = 0, probability=0.*****
Vmux_2level_size50[22]->in[10] mux_2level_size50[22]->in[10] 0
+  0
***** Signal mux_2level_size50[22]->in[11] density = 0, probability=0.*****
Vmux_2level_size50[22]->in[11] mux_2level_size50[22]->in[11] 0
+  0
***** Signal mux_2level_size50[22]->in[12] density = 0, probability=0.*****
Vmux_2level_size50[22]->in[12] mux_2level_size50[22]->in[12] 0
+  0
***** Signal mux_2level_size50[22]->in[13] density = 0, probability=0.*****
Vmux_2level_size50[22]->in[13] mux_2level_size50[22]->in[13] 0
+  0
***** Signal mux_2level_size50[22]->in[14] density = 0, probability=0.*****
Vmux_2level_size50[22]->in[14] mux_2level_size50[22]->in[14] 0
+  0
***** Signal mux_2level_size50[22]->in[15] density = 0, probability=0.*****
Vmux_2level_size50[22]->in[15] mux_2level_size50[22]->in[15] 0
+  0
***** Signal mux_2level_size50[22]->in[16] density = 0, probability=0.*****
Vmux_2level_size50[22]->in[16] mux_2level_size50[22]->in[16] 0
+  0
***** Signal mux_2level_size50[22]->in[17] density = 0, probability=0.*****
Vmux_2level_size50[22]->in[17] mux_2level_size50[22]->in[17] 0
+  0
***** Signal mux_2level_size50[22]->in[18] density = 0, probability=0.*****
Vmux_2level_size50[22]->in[18] mux_2level_size50[22]->in[18] 0
+  0
***** Signal mux_2level_size50[22]->in[19] density = 0, probability=0.*****
Vmux_2level_size50[22]->in[19] mux_2level_size50[22]->in[19] 0
+  0
***** Signal mux_2level_size50[22]->in[20] density = 0, probability=0.*****
Vmux_2level_size50[22]->in[20] mux_2level_size50[22]->in[20] 0
+  0
***** Signal mux_2level_size50[22]->in[21] density = 0, probability=0.*****
Vmux_2level_size50[22]->in[21] mux_2level_size50[22]->in[21] 0
+  0
***** Signal mux_2level_size50[22]->in[22] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[22]->in[22] mux_2level_size50[22]->in[22] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[22]->in[23] density = 0, probability=0.*****
Vmux_2level_size50[22]->in[23] mux_2level_size50[22]->in[23] 0
+  0
***** Signal mux_2level_size50[22]->in[24] density = 0, probability=0.*****
Vmux_2level_size50[22]->in[24] mux_2level_size50[22]->in[24] 0
+  0
***** Signal mux_2level_size50[22]->in[25] density = 0, probability=0.*****
Vmux_2level_size50[22]->in[25] mux_2level_size50[22]->in[25] 0
+  0
***** Signal mux_2level_size50[22]->in[26] density = 0, probability=0.*****
Vmux_2level_size50[22]->in[26] mux_2level_size50[22]->in[26] 0
+  0
***** Signal mux_2level_size50[22]->in[27] density = 0, probability=0.*****
Vmux_2level_size50[22]->in[27] mux_2level_size50[22]->in[27] 0
+  0
***** Signal mux_2level_size50[22]->in[28] density = 0, probability=0.*****
Vmux_2level_size50[22]->in[28] mux_2level_size50[22]->in[28] 0
+  0
***** Signal mux_2level_size50[22]->in[29] density = 0, probability=0.*****
Vmux_2level_size50[22]->in[29] mux_2level_size50[22]->in[29] 0
+  0
***** Signal mux_2level_size50[22]->in[30] density = 0, probability=0.*****
Vmux_2level_size50[22]->in[30] mux_2level_size50[22]->in[30] 0
+  0
***** Signal mux_2level_size50[22]->in[31] density = 0, probability=0.*****
Vmux_2level_size50[22]->in[31] mux_2level_size50[22]->in[31] 0
+  0
***** Signal mux_2level_size50[22]->in[32] density = 0, probability=0.*****
Vmux_2level_size50[22]->in[32] mux_2level_size50[22]->in[32] 0
+  0
***** Signal mux_2level_size50[22]->in[33] density = 0, probability=0.*****
Vmux_2level_size50[22]->in[33] mux_2level_size50[22]->in[33] 0
+  0
***** Signal mux_2level_size50[22]->in[34] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[22]->in[34] mux_2level_size50[22]->in[34] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[22]->in[35] density = 0, probability=0.*****
Vmux_2level_size50[22]->in[35] mux_2level_size50[22]->in[35] 0
+  0
***** Signal mux_2level_size50[22]->in[36] density = 0, probability=0.*****
Vmux_2level_size50[22]->in[36] mux_2level_size50[22]->in[36] 0
+  0
***** Signal mux_2level_size50[22]->in[37] density = 0, probability=0.*****
Vmux_2level_size50[22]->in[37] mux_2level_size50[22]->in[37] 0
+  0
***** Signal mux_2level_size50[22]->in[38] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[22]->in[38] mux_2level_size50[22]->in[38] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[22]->in[39] density = 0, probability=0.*****
Vmux_2level_size50[22]->in[39] mux_2level_size50[22]->in[39] 0
+  0
***** Signal mux_2level_size50[22]->in[40] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[22]->in[40] mux_2level_size50[22]->in[40] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[22]->in[41] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[22]->in[41] mux_2level_size50[22]->in[41] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[22]->in[42] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[22]->in[42] mux_2level_size50[22]->in[42] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[22]->in[43] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[22]->in[43] mux_2level_size50[22]->in[43] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[22]->in[44] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[22]->in[44] mux_2level_size50[22]->in[44] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[22]->in[45] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[22]->in[45] mux_2level_size50[22]->in[45] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[22]->in[46] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[22]->in[46] mux_2level_size50[22]->in[46] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[22]->in[47] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[22]->in[47] mux_2level_size50[22]->in[47] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[22]->in[48] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[22]->in[48] mux_2level_size50[22]->in[48] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[22]->in[49] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[22]->in[49] mux_2level_size50[22]->in[49] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
Vgvdd_mux_2level_size50[22] gvdd_mux_2level_size50[22] 0 vsp
***** Measurements *****
***** Rise delay *****
.meas tran delay_rise_idle_mux50[22]_in[4]_crossbar trig v(mux_2level_size50[22]->in[0]) val='input_thres_pct_rise*vsp' rise=1 td='clock_period'
+          targ v(mux_2level_size50[22]->out) val='output_thres_pct_rise*vsp' rise=1 td='clock_period'
***** Fall delay *****
.meas tran delay_fall_idle_mux50[22]_in[4]_crossbar trig v(mux_2level_size50[22]->in[0]) val='input_thres_pct_fall*vsp' fall=1 td='clock_period'
+          targ v(mux_2level_size50[22]->out) val='output_thres_pct_fall*vsp' fall=1 td='clock_period'
***** Rise timing period *****
.meas start_rise_idle_mux50[22]_in[4]_crossbar when v(mux_2level_size50[22]->in[0])='slew_lower_thres_pct_rise*vsp' rise=1 td='clock_period'
.meas tran switch_rise_idle_mux50[22]_in[4]_crossbar trig v(mux_2level_size50[22]->in[0]) val='slew_lower_thres_pct_rise*vsp' rise=1 td='clock_period'
+          targ v(mux_2level_size50[22]->out) val='slew_upper_thres_pct_rise*vsp' rise=1 td='clock_period'
***** Fall timing period *****
.meas start_fall_idle_mux50[22]_in[4]_crossbar when v(mux_2level_size50[22]->in[0])='slew_lower_thres_pct_fall*vsp' fall=1 td='clock_period'
.meas tran switch_fall_idle_mux50[22]_in[4]_crossbar trig v(mux_2level_size50[22]->in[0]) val='slew_lower_thres_pct_fall*vsp' fall=1 td='clock_period'
+          targ v(mux_2level_size50[22]->out) val='slew_upper_thres_pct_fall*vsp' fall=1 td='clock_period'
***** Leakage Power Measurement *****
.meas tran mux_2level_size50[22]_leakage_power avg p(Vgvdd_mux_2level_size50[22]) from=0 to='clock_period'
.meas tran leakage_idle_mux50[22]_in[4]_crossbar param='mux_2level_size50[22]_leakage_power'
***** Dynamic Power Measurement *****
.meas tran mux_2level_size50[22]_dynamic_power avg p(Vgvdd_mux_2level_size50[22]) from='clock_period' to='6*clock_period'
.meas tran mux_2level_size50[22]_energy_per_cycle param='mux_2level_size50[22]_dynamic_power*clock_period'
.meas tran dynamic_power_idle_mux50[22]_in[4]_crossbar  param='mux_2level_size50[22]_dynamic_power'
.meas tran energy_per_cycle_idle_mux50[22]_in[4]_crossbar  param='dynamic_power_idle_mux50[22]_in[4]_crossbar*clock_period'
.meas tran dynamic_rise_idle_mux50[22]_in[4]_crossbar avg p(Vgvdd_mux_2level_size50[22]) from='start_rise_idle_mux50[22]_in[4]_crossbar' to='start_rise_idle_mux50[22]_in[4]_crossbar+switch_rise_idle_mux50[22]_in[4]_crossbar'
.meas tran dynamic_fall_idle_mux50[22]_in[4]_crossbar avg p(Vgvdd_mux_2level_size50[22]) from='start_fall_idle_mux50[22]_in[4]_crossbar' to='start_fall_idle_mux50[22]_in[4]_crossbar+switch_fall_idle_mux50[22]_in[4]_crossbar'
.meas tran sum_leakage_power_mux[0to22]
+          param='sum_leakage_power_mux[0to21]+leakage_idle_mux50[22]_in[4]_crossbar'
.meas tran sum_energy_per_cycle_mux[0to22]
+          param='sum_energy_per_cycle_mux[0to21]+energy_per_cycle_idle_mux50[22]_in[4]_crossbar'
Xload_inv[22]_no0 mux_2level_size50[22]->out mux_2level_size50[22]->out_out[0] gvdd_load 0 inv size=5
.meas tran sum_leakage_power_pb_mux[0to22]
+          param='sum_leakage_power_pb_mux[0to21]+leakage_idle_mux50[22]_in[4]_crossbar'
.meas tran sum_energy_per_cycle_pb_mux[0to22]
+          param='sum_energy_per_cycle_pb_mux[0to21]+energy_per_cycle_idle_mux50[22]_in[4]_crossbar'
Xmux_2level_size50[23] mux_2level_size50[23]->in[0] mux_2level_size50[23]->in[1] mux_2level_size50[23]->in[2] mux_2level_size50[23]->in[3] mux_2level_size50[23]->in[4] mux_2level_size50[23]->in[5] mux_2level_size50[23]->in[6] mux_2level_size50[23]->in[7] mux_2level_size50[23]->in[8] mux_2level_size50[23]->in[9] mux_2level_size50[23]->in[10] mux_2level_size50[23]->in[11] mux_2level_size50[23]->in[12] mux_2level_size50[23]->in[13] mux_2level_size50[23]->in[14] mux_2level_size50[23]->in[15] mux_2level_size50[23]->in[16] mux_2level_size50[23]->in[17] mux_2level_size50[23]->in[18] mux_2level_size50[23]->in[19] mux_2level_size50[23]->in[20] mux_2level_size50[23]->in[21] mux_2level_size50[23]->in[22] mux_2level_size50[23]->in[23] mux_2level_size50[23]->in[24] mux_2level_size50[23]->in[25] mux_2level_size50[23]->in[26] mux_2level_size50[23]->in[27] mux_2level_size50[23]->in[28] mux_2level_size50[23]->in[29] mux_2level_size50[23]->in[30] mux_2level_size50[23]->in[31] mux_2level_size50[23]->in[32] mux_2level_size50[23]->in[33] mux_2level_size50[23]->in[34] mux_2level_size50[23]->in[35] mux_2level_size50[23]->in[36] mux_2level_size50[23]->in[37] mux_2level_size50[23]->in[38] mux_2level_size50[23]->in[39] mux_2level_size50[23]->in[40] mux_2level_size50[23]->in[41] mux_2level_size50[23]->in[42] mux_2level_size50[23]->in[43] mux_2level_size50[23]->in[44] mux_2level_size50[23]->in[45] mux_2level_size50[23]->in[46] mux_2level_size50[23]->in[47] mux_2level_size50[23]->in[48] mux_2level_size50[23]->in[49] mux_2level_size50[23]->out sram[368]->outb sram[368]->out sram[369]->out sram[369]->outb sram[370]->out sram[370]->outb sram[371]->out sram[371]->outb sram[372]->out sram[372]->outb sram[373]->out sram[373]->outb sram[374]->out sram[374]->outb sram[375]->out sram[375]->outb sram[376]->outb sram[376]->out sram[377]->out sram[377]->outb sram[378]->out sram[378]->outb sram[379]->out sram[379]->outb sram[380]->out sram[380]->outb sram[381]->out sram[381]->outb sram[382]->out sram[382]->outb sram[383]->out sram[383]->outb gvdd_mux_2level_size50[23] 0 mux_2level_size50
***** SRAM bits for MUX[23], level=2, select_path_id=0. *****
*****1000000010000000*****
Xsram[368] sram->in sram[368]->out sram[368]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[368]->out) 0
.nodeset V(sram[368]->outb) vsp
Xsram[369] sram->in sram[369]->out sram[369]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[369]->out) 0
.nodeset V(sram[369]->outb) vsp
Xsram[370] sram->in sram[370]->out sram[370]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[370]->out) 0
.nodeset V(sram[370]->outb) vsp
Xsram[371] sram->in sram[371]->out sram[371]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[371]->out) 0
.nodeset V(sram[371]->outb) vsp
Xsram[372] sram->in sram[372]->out sram[372]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[372]->out) 0
.nodeset V(sram[372]->outb) vsp
Xsram[373] sram->in sram[373]->out sram[373]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[373]->out) 0
.nodeset V(sram[373]->outb) vsp
Xsram[374] sram->in sram[374]->out sram[374]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[374]->out) 0
.nodeset V(sram[374]->outb) vsp
Xsram[375] sram->in sram[375]->out sram[375]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[375]->out) 0
.nodeset V(sram[375]->outb) vsp
Xsram[376] sram->in sram[376]->out sram[376]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[376]->out) 0
.nodeset V(sram[376]->outb) vsp
Xsram[377] sram->in sram[377]->out sram[377]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[377]->out) 0
.nodeset V(sram[377]->outb) vsp
Xsram[378] sram->in sram[378]->out sram[378]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[378]->out) 0
.nodeset V(sram[378]->outb) vsp
Xsram[379] sram->in sram[379]->out sram[379]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[379]->out) 0
.nodeset V(sram[379]->outb) vsp
Xsram[380] sram->in sram[380]->out sram[380]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[380]->out) 0
.nodeset V(sram[380]->outb) vsp
Xsram[381] sram->in sram[381]->out sram[381]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[381]->out) 0
.nodeset V(sram[381]->outb) vsp
Xsram[382] sram->in sram[382]->out sram[382]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[382]->out) 0
.nodeset V(sram[382]->outb) vsp
Xsram[383] sram->in sram[383]->out sram[383]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[383]->out) 0
.nodeset V(sram[383]->outb) vsp
***** Signal mux_2level_size50[23]->in[0] density = 0, probability=0.*****
Vmux_2level_size50[23]->in[0] mux_2level_size50[23]->in[0] 0
+  0
***** Signal mux_2level_size50[23]->in[1] density = 0, probability=0.*****
Vmux_2level_size50[23]->in[1] mux_2level_size50[23]->in[1] 0
+  0
***** Signal mux_2level_size50[23]->in[2] density = 0, probability=0.*****
Vmux_2level_size50[23]->in[2] mux_2level_size50[23]->in[2] 0
+  0
***** Signal mux_2level_size50[23]->in[3] density = 0, probability=0.*****
Vmux_2level_size50[23]->in[3] mux_2level_size50[23]->in[3] 0
+  0
***** Signal mux_2level_size50[23]->in[4] density = 0, probability=0.*****
Vmux_2level_size50[23]->in[4] mux_2level_size50[23]->in[4] 0
+  0
***** Signal mux_2level_size50[23]->in[5] density = 0, probability=0.*****
Vmux_2level_size50[23]->in[5] mux_2level_size50[23]->in[5] 0
+  0
***** Signal mux_2level_size50[23]->in[6] density = 0, probability=0.*****
Vmux_2level_size50[23]->in[6] mux_2level_size50[23]->in[6] 0
+  0
***** Signal mux_2level_size50[23]->in[7] density = 0, probability=0.*****
Vmux_2level_size50[23]->in[7] mux_2level_size50[23]->in[7] 0
+  0
***** Signal mux_2level_size50[23]->in[8] density = 0, probability=0.*****
Vmux_2level_size50[23]->in[8] mux_2level_size50[23]->in[8] 0
+  0
***** Signal mux_2level_size50[23]->in[9] density = 0, probability=0.*****
Vmux_2level_size50[23]->in[9] mux_2level_size50[23]->in[9] 0
+  0
***** Signal mux_2level_size50[23]->in[10] density = 0, probability=0.*****
Vmux_2level_size50[23]->in[10] mux_2level_size50[23]->in[10] 0
+  0
***** Signal mux_2level_size50[23]->in[11] density = 0, probability=0.*****
Vmux_2level_size50[23]->in[11] mux_2level_size50[23]->in[11] 0
+  0
***** Signal mux_2level_size50[23]->in[12] density = 0, probability=0.*****
Vmux_2level_size50[23]->in[12] mux_2level_size50[23]->in[12] 0
+  0
***** Signal mux_2level_size50[23]->in[13] density = 0, probability=0.*****
Vmux_2level_size50[23]->in[13] mux_2level_size50[23]->in[13] 0
+  0
***** Signal mux_2level_size50[23]->in[14] density = 0, probability=0.*****
Vmux_2level_size50[23]->in[14] mux_2level_size50[23]->in[14] 0
+  0
***** Signal mux_2level_size50[23]->in[15] density = 0, probability=0.*****
Vmux_2level_size50[23]->in[15] mux_2level_size50[23]->in[15] 0
+  0
***** Signal mux_2level_size50[23]->in[16] density = 0, probability=0.*****
Vmux_2level_size50[23]->in[16] mux_2level_size50[23]->in[16] 0
+  0
***** Signal mux_2level_size50[23]->in[17] density = 0, probability=0.*****
Vmux_2level_size50[23]->in[17] mux_2level_size50[23]->in[17] 0
+  0
***** Signal mux_2level_size50[23]->in[18] density = 0, probability=0.*****
Vmux_2level_size50[23]->in[18] mux_2level_size50[23]->in[18] 0
+  0
***** Signal mux_2level_size50[23]->in[19] density = 0, probability=0.*****
Vmux_2level_size50[23]->in[19] mux_2level_size50[23]->in[19] 0
+  0
***** Signal mux_2level_size50[23]->in[20] density = 0, probability=0.*****
Vmux_2level_size50[23]->in[20] mux_2level_size50[23]->in[20] 0
+  0
***** Signal mux_2level_size50[23]->in[21] density = 0, probability=0.*****
Vmux_2level_size50[23]->in[21] mux_2level_size50[23]->in[21] 0
+  0
***** Signal mux_2level_size50[23]->in[22] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[23]->in[22] mux_2level_size50[23]->in[22] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[23]->in[23] density = 0, probability=0.*****
Vmux_2level_size50[23]->in[23] mux_2level_size50[23]->in[23] 0
+  0
***** Signal mux_2level_size50[23]->in[24] density = 0, probability=0.*****
Vmux_2level_size50[23]->in[24] mux_2level_size50[23]->in[24] 0
+  0
***** Signal mux_2level_size50[23]->in[25] density = 0, probability=0.*****
Vmux_2level_size50[23]->in[25] mux_2level_size50[23]->in[25] 0
+  0
***** Signal mux_2level_size50[23]->in[26] density = 0, probability=0.*****
Vmux_2level_size50[23]->in[26] mux_2level_size50[23]->in[26] 0
+  0
***** Signal mux_2level_size50[23]->in[27] density = 0, probability=0.*****
Vmux_2level_size50[23]->in[27] mux_2level_size50[23]->in[27] 0
+  0
***** Signal mux_2level_size50[23]->in[28] density = 0, probability=0.*****
Vmux_2level_size50[23]->in[28] mux_2level_size50[23]->in[28] 0
+  0
***** Signal mux_2level_size50[23]->in[29] density = 0, probability=0.*****
Vmux_2level_size50[23]->in[29] mux_2level_size50[23]->in[29] 0
+  0
***** Signal mux_2level_size50[23]->in[30] density = 0, probability=0.*****
Vmux_2level_size50[23]->in[30] mux_2level_size50[23]->in[30] 0
+  0
***** Signal mux_2level_size50[23]->in[31] density = 0, probability=0.*****
Vmux_2level_size50[23]->in[31] mux_2level_size50[23]->in[31] 0
+  0
***** Signal mux_2level_size50[23]->in[32] density = 0, probability=0.*****
Vmux_2level_size50[23]->in[32] mux_2level_size50[23]->in[32] 0
+  0
***** Signal mux_2level_size50[23]->in[33] density = 0, probability=0.*****
Vmux_2level_size50[23]->in[33] mux_2level_size50[23]->in[33] 0
+  0
***** Signal mux_2level_size50[23]->in[34] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[23]->in[34] mux_2level_size50[23]->in[34] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[23]->in[35] density = 0, probability=0.*****
Vmux_2level_size50[23]->in[35] mux_2level_size50[23]->in[35] 0
+  0
***** Signal mux_2level_size50[23]->in[36] density = 0, probability=0.*****
Vmux_2level_size50[23]->in[36] mux_2level_size50[23]->in[36] 0
+  0
***** Signal mux_2level_size50[23]->in[37] density = 0, probability=0.*****
Vmux_2level_size50[23]->in[37] mux_2level_size50[23]->in[37] 0
+  0
***** Signal mux_2level_size50[23]->in[38] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[23]->in[38] mux_2level_size50[23]->in[38] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[23]->in[39] density = 0, probability=0.*****
Vmux_2level_size50[23]->in[39] mux_2level_size50[23]->in[39] 0
+  0
***** Signal mux_2level_size50[23]->in[40] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[23]->in[40] mux_2level_size50[23]->in[40] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[23]->in[41] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[23]->in[41] mux_2level_size50[23]->in[41] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[23]->in[42] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[23]->in[42] mux_2level_size50[23]->in[42] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[23]->in[43] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[23]->in[43] mux_2level_size50[23]->in[43] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[23]->in[44] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[23]->in[44] mux_2level_size50[23]->in[44] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[23]->in[45] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[23]->in[45] mux_2level_size50[23]->in[45] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[23]->in[46] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[23]->in[46] mux_2level_size50[23]->in[46] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[23]->in[47] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[23]->in[47] mux_2level_size50[23]->in[47] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[23]->in[48] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[23]->in[48] mux_2level_size50[23]->in[48] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[23]->in[49] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[23]->in[49] mux_2level_size50[23]->in[49] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
Vgvdd_mux_2level_size50[23] gvdd_mux_2level_size50[23] 0 vsp
***** Measurements *****
***** Rise delay *****
.meas tran delay_rise_idle_mux50[23]_in[5]_crossbar trig v(mux_2level_size50[23]->in[0]) val='input_thres_pct_rise*vsp' rise=1 td='clock_period'
+          targ v(mux_2level_size50[23]->out) val='output_thres_pct_rise*vsp' rise=1 td='clock_period'
***** Fall delay *****
.meas tran delay_fall_idle_mux50[23]_in[5]_crossbar trig v(mux_2level_size50[23]->in[0]) val='input_thres_pct_fall*vsp' fall=1 td='clock_period'
+          targ v(mux_2level_size50[23]->out) val='output_thres_pct_fall*vsp' fall=1 td='clock_period'
***** Rise timing period *****
.meas start_rise_idle_mux50[23]_in[5]_crossbar when v(mux_2level_size50[23]->in[0])='slew_lower_thres_pct_rise*vsp' rise=1 td='clock_period'
.meas tran switch_rise_idle_mux50[23]_in[5]_crossbar trig v(mux_2level_size50[23]->in[0]) val='slew_lower_thres_pct_rise*vsp' rise=1 td='clock_period'
+          targ v(mux_2level_size50[23]->out) val='slew_upper_thres_pct_rise*vsp' rise=1 td='clock_period'
***** Fall timing period *****
.meas start_fall_idle_mux50[23]_in[5]_crossbar when v(mux_2level_size50[23]->in[0])='slew_lower_thres_pct_fall*vsp' fall=1 td='clock_period'
.meas tran switch_fall_idle_mux50[23]_in[5]_crossbar trig v(mux_2level_size50[23]->in[0]) val='slew_lower_thres_pct_fall*vsp' fall=1 td='clock_period'
+          targ v(mux_2level_size50[23]->out) val='slew_upper_thres_pct_fall*vsp' fall=1 td='clock_period'
***** Leakage Power Measurement *****
.meas tran mux_2level_size50[23]_leakage_power avg p(Vgvdd_mux_2level_size50[23]) from=0 to='clock_period'
.meas tran leakage_idle_mux50[23]_in[5]_crossbar param='mux_2level_size50[23]_leakage_power'
***** Dynamic Power Measurement *****
.meas tran mux_2level_size50[23]_dynamic_power avg p(Vgvdd_mux_2level_size50[23]) from='clock_period' to='6*clock_period'
.meas tran mux_2level_size50[23]_energy_per_cycle param='mux_2level_size50[23]_dynamic_power*clock_period'
.meas tran dynamic_power_idle_mux50[23]_in[5]_crossbar  param='mux_2level_size50[23]_dynamic_power'
.meas tran energy_per_cycle_idle_mux50[23]_in[5]_crossbar  param='dynamic_power_idle_mux50[23]_in[5]_crossbar*clock_period'
.meas tran dynamic_rise_idle_mux50[23]_in[5]_crossbar avg p(Vgvdd_mux_2level_size50[23]) from='start_rise_idle_mux50[23]_in[5]_crossbar' to='start_rise_idle_mux50[23]_in[5]_crossbar+switch_rise_idle_mux50[23]_in[5]_crossbar'
.meas tran dynamic_fall_idle_mux50[23]_in[5]_crossbar avg p(Vgvdd_mux_2level_size50[23]) from='start_fall_idle_mux50[23]_in[5]_crossbar' to='start_fall_idle_mux50[23]_in[5]_crossbar+switch_fall_idle_mux50[23]_in[5]_crossbar'
.meas tran sum_leakage_power_mux[0to23]
+          param='sum_leakage_power_mux[0to22]+leakage_idle_mux50[23]_in[5]_crossbar'
.meas tran sum_energy_per_cycle_mux[0to23]
+          param='sum_energy_per_cycle_mux[0to22]+energy_per_cycle_idle_mux50[23]_in[5]_crossbar'
Xload_inv[23]_no0 mux_2level_size50[23]->out mux_2level_size50[23]->out_out[0] gvdd_load 0 inv size=5
.meas tran sum_leakage_power_pb_mux[0to23]
+          param='sum_leakage_power_pb_mux[0to22]+leakage_idle_mux50[23]_in[5]_crossbar'
.meas tran sum_energy_per_cycle_pb_mux[0to23]
+          param='sum_energy_per_cycle_pb_mux[0to22]+energy_per_cycle_idle_mux50[23]_in[5]_crossbar'
Xmux_2level_size50[24] mux_2level_size50[24]->in[0] mux_2level_size50[24]->in[1] mux_2level_size50[24]->in[2] mux_2level_size50[24]->in[3] mux_2level_size50[24]->in[4] mux_2level_size50[24]->in[5] mux_2level_size50[24]->in[6] mux_2level_size50[24]->in[7] mux_2level_size50[24]->in[8] mux_2level_size50[24]->in[9] mux_2level_size50[24]->in[10] mux_2level_size50[24]->in[11] mux_2level_size50[24]->in[12] mux_2level_size50[24]->in[13] mux_2level_size50[24]->in[14] mux_2level_size50[24]->in[15] mux_2level_size50[24]->in[16] mux_2level_size50[24]->in[17] mux_2level_size50[24]->in[18] mux_2level_size50[24]->in[19] mux_2level_size50[24]->in[20] mux_2level_size50[24]->in[21] mux_2level_size50[24]->in[22] mux_2level_size50[24]->in[23] mux_2level_size50[24]->in[24] mux_2level_size50[24]->in[25] mux_2level_size50[24]->in[26] mux_2level_size50[24]->in[27] mux_2level_size50[24]->in[28] mux_2level_size50[24]->in[29] mux_2level_size50[24]->in[30] mux_2level_size50[24]->in[31] mux_2level_size50[24]->in[32] mux_2level_size50[24]->in[33] mux_2level_size50[24]->in[34] mux_2level_size50[24]->in[35] mux_2level_size50[24]->in[36] mux_2level_size50[24]->in[37] mux_2level_size50[24]->in[38] mux_2level_size50[24]->in[39] mux_2level_size50[24]->in[40] mux_2level_size50[24]->in[41] mux_2level_size50[24]->in[42] mux_2level_size50[24]->in[43] mux_2level_size50[24]->in[44] mux_2level_size50[24]->in[45] mux_2level_size50[24]->in[46] mux_2level_size50[24]->in[47] mux_2level_size50[24]->in[48] mux_2level_size50[24]->in[49] mux_2level_size50[24]->out sram[384]->outb sram[384]->out sram[385]->out sram[385]->outb sram[386]->out sram[386]->outb sram[387]->out sram[387]->outb sram[388]->out sram[388]->outb sram[389]->out sram[389]->outb sram[390]->out sram[390]->outb sram[391]->out sram[391]->outb sram[392]->outb sram[392]->out sram[393]->out sram[393]->outb sram[394]->out sram[394]->outb sram[395]->out sram[395]->outb sram[396]->out sram[396]->outb sram[397]->out sram[397]->outb sram[398]->out sram[398]->outb sram[399]->out sram[399]->outb gvdd_mux_2level_size50[24] 0 mux_2level_size50
***** SRAM bits for MUX[24], level=2, select_path_id=0. *****
*****1000000010000000*****
Xsram[384] sram->in sram[384]->out sram[384]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[384]->out) 0
.nodeset V(sram[384]->outb) vsp
Xsram[385] sram->in sram[385]->out sram[385]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[385]->out) 0
.nodeset V(sram[385]->outb) vsp
Xsram[386] sram->in sram[386]->out sram[386]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[386]->out) 0
.nodeset V(sram[386]->outb) vsp
Xsram[387] sram->in sram[387]->out sram[387]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[387]->out) 0
.nodeset V(sram[387]->outb) vsp
Xsram[388] sram->in sram[388]->out sram[388]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[388]->out) 0
.nodeset V(sram[388]->outb) vsp
Xsram[389] sram->in sram[389]->out sram[389]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[389]->out) 0
.nodeset V(sram[389]->outb) vsp
Xsram[390] sram->in sram[390]->out sram[390]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[390]->out) 0
.nodeset V(sram[390]->outb) vsp
Xsram[391] sram->in sram[391]->out sram[391]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[391]->out) 0
.nodeset V(sram[391]->outb) vsp
Xsram[392] sram->in sram[392]->out sram[392]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[392]->out) 0
.nodeset V(sram[392]->outb) vsp
Xsram[393] sram->in sram[393]->out sram[393]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[393]->out) 0
.nodeset V(sram[393]->outb) vsp
Xsram[394] sram->in sram[394]->out sram[394]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[394]->out) 0
.nodeset V(sram[394]->outb) vsp
Xsram[395] sram->in sram[395]->out sram[395]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[395]->out) 0
.nodeset V(sram[395]->outb) vsp
Xsram[396] sram->in sram[396]->out sram[396]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[396]->out) 0
.nodeset V(sram[396]->outb) vsp
Xsram[397] sram->in sram[397]->out sram[397]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[397]->out) 0
.nodeset V(sram[397]->outb) vsp
Xsram[398] sram->in sram[398]->out sram[398]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[398]->out) 0
.nodeset V(sram[398]->outb) vsp
Xsram[399] sram->in sram[399]->out sram[399]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[399]->out) 0
.nodeset V(sram[399]->outb) vsp
***** Signal mux_2level_size50[24]->in[0] density = 0, probability=0.*****
Vmux_2level_size50[24]->in[0] mux_2level_size50[24]->in[0] 0
+  0
***** Signal mux_2level_size50[24]->in[1] density = 0, probability=0.*****
Vmux_2level_size50[24]->in[1] mux_2level_size50[24]->in[1] 0
+  0
***** Signal mux_2level_size50[24]->in[2] density = 0, probability=0.*****
Vmux_2level_size50[24]->in[2] mux_2level_size50[24]->in[2] 0
+  0
***** Signal mux_2level_size50[24]->in[3] density = 0, probability=0.*****
Vmux_2level_size50[24]->in[3] mux_2level_size50[24]->in[3] 0
+  0
***** Signal mux_2level_size50[24]->in[4] density = 0, probability=0.*****
Vmux_2level_size50[24]->in[4] mux_2level_size50[24]->in[4] 0
+  0
***** Signal mux_2level_size50[24]->in[5] density = 0, probability=0.*****
Vmux_2level_size50[24]->in[5] mux_2level_size50[24]->in[5] 0
+  0
***** Signal mux_2level_size50[24]->in[6] density = 0, probability=0.*****
Vmux_2level_size50[24]->in[6] mux_2level_size50[24]->in[6] 0
+  0
***** Signal mux_2level_size50[24]->in[7] density = 0, probability=0.*****
Vmux_2level_size50[24]->in[7] mux_2level_size50[24]->in[7] 0
+  0
***** Signal mux_2level_size50[24]->in[8] density = 0, probability=0.*****
Vmux_2level_size50[24]->in[8] mux_2level_size50[24]->in[8] 0
+  0
***** Signal mux_2level_size50[24]->in[9] density = 0, probability=0.*****
Vmux_2level_size50[24]->in[9] mux_2level_size50[24]->in[9] 0
+  0
***** Signal mux_2level_size50[24]->in[10] density = 0, probability=0.*****
Vmux_2level_size50[24]->in[10] mux_2level_size50[24]->in[10] 0
+  0
***** Signal mux_2level_size50[24]->in[11] density = 0, probability=0.*****
Vmux_2level_size50[24]->in[11] mux_2level_size50[24]->in[11] 0
+  0
***** Signal mux_2level_size50[24]->in[12] density = 0, probability=0.*****
Vmux_2level_size50[24]->in[12] mux_2level_size50[24]->in[12] 0
+  0
***** Signal mux_2level_size50[24]->in[13] density = 0, probability=0.*****
Vmux_2level_size50[24]->in[13] mux_2level_size50[24]->in[13] 0
+  0
***** Signal mux_2level_size50[24]->in[14] density = 0, probability=0.*****
Vmux_2level_size50[24]->in[14] mux_2level_size50[24]->in[14] 0
+  0
***** Signal mux_2level_size50[24]->in[15] density = 0, probability=0.*****
Vmux_2level_size50[24]->in[15] mux_2level_size50[24]->in[15] 0
+  0
***** Signal mux_2level_size50[24]->in[16] density = 0, probability=0.*****
Vmux_2level_size50[24]->in[16] mux_2level_size50[24]->in[16] 0
+  0
***** Signal mux_2level_size50[24]->in[17] density = 0, probability=0.*****
Vmux_2level_size50[24]->in[17] mux_2level_size50[24]->in[17] 0
+  0
***** Signal mux_2level_size50[24]->in[18] density = 0, probability=0.*****
Vmux_2level_size50[24]->in[18] mux_2level_size50[24]->in[18] 0
+  0
***** Signal mux_2level_size50[24]->in[19] density = 0, probability=0.*****
Vmux_2level_size50[24]->in[19] mux_2level_size50[24]->in[19] 0
+  0
***** Signal mux_2level_size50[24]->in[20] density = 0, probability=0.*****
Vmux_2level_size50[24]->in[20] mux_2level_size50[24]->in[20] 0
+  0
***** Signal mux_2level_size50[24]->in[21] density = 0, probability=0.*****
Vmux_2level_size50[24]->in[21] mux_2level_size50[24]->in[21] 0
+  0
***** Signal mux_2level_size50[24]->in[22] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[24]->in[22] mux_2level_size50[24]->in[22] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[24]->in[23] density = 0, probability=0.*****
Vmux_2level_size50[24]->in[23] mux_2level_size50[24]->in[23] 0
+  0
***** Signal mux_2level_size50[24]->in[24] density = 0, probability=0.*****
Vmux_2level_size50[24]->in[24] mux_2level_size50[24]->in[24] 0
+  0
***** Signal mux_2level_size50[24]->in[25] density = 0, probability=0.*****
Vmux_2level_size50[24]->in[25] mux_2level_size50[24]->in[25] 0
+  0
***** Signal mux_2level_size50[24]->in[26] density = 0, probability=0.*****
Vmux_2level_size50[24]->in[26] mux_2level_size50[24]->in[26] 0
+  0
***** Signal mux_2level_size50[24]->in[27] density = 0, probability=0.*****
Vmux_2level_size50[24]->in[27] mux_2level_size50[24]->in[27] 0
+  0
***** Signal mux_2level_size50[24]->in[28] density = 0, probability=0.*****
Vmux_2level_size50[24]->in[28] mux_2level_size50[24]->in[28] 0
+  0
***** Signal mux_2level_size50[24]->in[29] density = 0, probability=0.*****
Vmux_2level_size50[24]->in[29] mux_2level_size50[24]->in[29] 0
+  0
***** Signal mux_2level_size50[24]->in[30] density = 0, probability=0.*****
Vmux_2level_size50[24]->in[30] mux_2level_size50[24]->in[30] 0
+  0
***** Signal mux_2level_size50[24]->in[31] density = 0, probability=0.*****
Vmux_2level_size50[24]->in[31] mux_2level_size50[24]->in[31] 0
+  0
***** Signal mux_2level_size50[24]->in[32] density = 0, probability=0.*****
Vmux_2level_size50[24]->in[32] mux_2level_size50[24]->in[32] 0
+  0
***** Signal mux_2level_size50[24]->in[33] density = 0, probability=0.*****
Vmux_2level_size50[24]->in[33] mux_2level_size50[24]->in[33] 0
+  0
***** Signal mux_2level_size50[24]->in[34] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[24]->in[34] mux_2level_size50[24]->in[34] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[24]->in[35] density = 0, probability=0.*****
Vmux_2level_size50[24]->in[35] mux_2level_size50[24]->in[35] 0
+  0
***** Signal mux_2level_size50[24]->in[36] density = 0, probability=0.*****
Vmux_2level_size50[24]->in[36] mux_2level_size50[24]->in[36] 0
+  0
***** Signal mux_2level_size50[24]->in[37] density = 0, probability=0.*****
Vmux_2level_size50[24]->in[37] mux_2level_size50[24]->in[37] 0
+  0
***** Signal mux_2level_size50[24]->in[38] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[24]->in[38] mux_2level_size50[24]->in[38] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[24]->in[39] density = 0, probability=0.*****
Vmux_2level_size50[24]->in[39] mux_2level_size50[24]->in[39] 0
+  0
***** Signal mux_2level_size50[24]->in[40] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[24]->in[40] mux_2level_size50[24]->in[40] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[24]->in[41] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[24]->in[41] mux_2level_size50[24]->in[41] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[24]->in[42] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[24]->in[42] mux_2level_size50[24]->in[42] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[24]->in[43] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[24]->in[43] mux_2level_size50[24]->in[43] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[24]->in[44] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[24]->in[44] mux_2level_size50[24]->in[44] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[24]->in[45] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[24]->in[45] mux_2level_size50[24]->in[45] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[24]->in[46] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[24]->in[46] mux_2level_size50[24]->in[46] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[24]->in[47] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[24]->in[47] mux_2level_size50[24]->in[47] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[24]->in[48] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[24]->in[48] mux_2level_size50[24]->in[48] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[24]->in[49] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[24]->in[49] mux_2level_size50[24]->in[49] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
Vgvdd_mux_2level_size50[24] gvdd_mux_2level_size50[24] 0 vsp
***** Measurements *****
***** Rise delay *****
.meas tran delay_rise_idle_mux50[24]_in[0]_crossbar trig v(mux_2level_size50[24]->in[0]) val='input_thres_pct_rise*vsp' rise=1 td='clock_period'
+          targ v(mux_2level_size50[24]->out) val='output_thres_pct_rise*vsp' rise=1 td='clock_period'
***** Fall delay *****
.meas tran delay_fall_idle_mux50[24]_in[0]_crossbar trig v(mux_2level_size50[24]->in[0]) val='input_thres_pct_fall*vsp' fall=1 td='clock_period'
+          targ v(mux_2level_size50[24]->out) val='output_thres_pct_fall*vsp' fall=1 td='clock_period'
***** Rise timing period *****
.meas start_rise_idle_mux50[24]_in[0]_crossbar when v(mux_2level_size50[24]->in[0])='slew_lower_thres_pct_rise*vsp' rise=1 td='clock_period'
.meas tran switch_rise_idle_mux50[24]_in[0]_crossbar trig v(mux_2level_size50[24]->in[0]) val='slew_lower_thres_pct_rise*vsp' rise=1 td='clock_period'
+          targ v(mux_2level_size50[24]->out) val='slew_upper_thres_pct_rise*vsp' rise=1 td='clock_period'
***** Fall timing period *****
.meas start_fall_idle_mux50[24]_in[0]_crossbar when v(mux_2level_size50[24]->in[0])='slew_lower_thres_pct_fall*vsp' fall=1 td='clock_period'
.meas tran switch_fall_idle_mux50[24]_in[0]_crossbar trig v(mux_2level_size50[24]->in[0]) val='slew_lower_thres_pct_fall*vsp' fall=1 td='clock_period'
+          targ v(mux_2level_size50[24]->out) val='slew_upper_thres_pct_fall*vsp' fall=1 td='clock_period'
***** Leakage Power Measurement *****
.meas tran mux_2level_size50[24]_leakage_power avg p(Vgvdd_mux_2level_size50[24]) from=0 to='clock_period'
.meas tran leakage_idle_mux50[24]_in[0]_crossbar param='mux_2level_size50[24]_leakage_power'
***** Dynamic Power Measurement *****
.meas tran mux_2level_size50[24]_dynamic_power avg p(Vgvdd_mux_2level_size50[24]) from='clock_period' to='6*clock_period'
.meas tran mux_2level_size50[24]_energy_per_cycle param='mux_2level_size50[24]_dynamic_power*clock_period'
.meas tran dynamic_power_idle_mux50[24]_in[0]_crossbar  param='mux_2level_size50[24]_dynamic_power'
.meas tran energy_per_cycle_idle_mux50[24]_in[0]_crossbar  param='dynamic_power_idle_mux50[24]_in[0]_crossbar*clock_period'
.meas tran dynamic_rise_idle_mux50[24]_in[0]_crossbar avg p(Vgvdd_mux_2level_size50[24]) from='start_rise_idle_mux50[24]_in[0]_crossbar' to='start_rise_idle_mux50[24]_in[0]_crossbar+switch_rise_idle_mux50[24]_in[0]_crossbar'
.meas tran dynamic_fall_idle_mux50[24]_in[0]_crossbar avg p(Vgvdd_mux_2level_size50[24]) from='start_fall_idle_mux50[24]_in[0]_crossbar' to='start_fall_idle_mux50[24]_in[0]_crossbar+switch_fall_idle_mux50[24]_in[0]_crossbar'
.meas tran sum_leakage_power_mux[0to24]
+          param='sum_leakage_power_mux[0to23]+leakage_idle_mux50[24]_in[0]_crossbar'
.meas tran sum_energy_per_cycle_mux[0to24]
+          param='sum_energy_per_cycle_mux[0to23]+energy_per_cycle_idle_mux50[24]_in[0]_crossbar'
Xload_inv[24]_no0 mux_2level_size50[24]->out mux_2level_size50[24]->out_out[0] gvdd_load 0 inv size=5
.meas tran sum_leakage_power_pb_mux[0to24]
+          param='sum_leakage_power_pb_mux[0to23]+leakage_idle_mux50[24]_in[0]_crossbar'
.meas tran sum_energy_per_cycle_pb_mux[0to24]
+          param='sum_energy_per_cycle_pb_mux[0to23]+energy_per_cycle_idle_mux50[24]_in[0]_crossbar'
Xmux_2level_size50[25] mux_2level_size50[25]->in[0] mux_2level_size50[25]->in[1] mux_2level_size50[25]->in[2] mux_2level_size50[25]->in[3] mux_2level_size50[25]->in[4] mux_2level_size50[25]->in[5] mux_2level_size50[25]->in[6] mux_2level_size50[25]->in[7] mux_2level_size50[25]->in[8] mux_2level_size50[25]->in[9] mux_2level_size50[25]->in[10] mux_2level_size50[25]->in[11] mux_2level_size50[25]->in[12] mux_2level_size50[25]->in[13] mux_2level_size50[25]->in[14] mux_2level_size50[25]->in[15] mux_2level_size50[25]->in[16] mux_2level_size50[25]->in[17] mux_2level_size50[25]->in[18] mux_2level_size50[25]->in[19] mux_2level_size50[25]->in[20] mux_2level_size50[25]->in[21] mux_2level_size50[25]->in[22] mux_2level_size50[25]->in[23] mux_2level_size50[25]->in[24] mux_2level_size50[25]->in[25] mux_2level_size50[25]->in[26] mux_2level_size50[25]->in[27] mux_2level_size50[25]->in[28] mux_2level_size50[25]->in[29] mux_2level_size50[25]->in[30] mux_2level_size50[25]->in[31] mux_2level_size50[25]->in[32] mux_2level_size50[25]->in[33] mux_2level_size50[25]->in[34] mux_2level_size50[25]->in[35] mux_2level_size50[25]->in[36] mux_2level_size50[25]->in[37] mux_2level_size50[25]->in[38] mux_2level_size50[25]->in[39] mux_2level_size50[25]->in[40] mux_2level_size50[25]->in[41] mux_2level_size50[25]->in[42] mux_2level_size50[25]->in[43] mux_2level_size50[25]->in[44] mux_2level_size50[25]->in[45] mux_2level_size50[25]->in[46] mux_2level_size50[25]->in[47] mux_2level_size50[25]->in[48] mux_2level_size50[25]->in[49] mux_2level_size50[25]->out sram[400]->outb sram[400]->out sram[401]->out sram[401]->outb sram[402]->out sram[402]->outb sram[403]->out sram[403]->outb sram[404]->out sram[404]->outb sram[405]->out sram[405]->outb sram[406]->out sram[406]->outb sram[407]->out sram[407]->outb sram[408]->outb sram[408]->out sram[409]->out sram[409]->outb sram[410]->out sram[410]->outb sram[411]->out sram[411]->outb sram[412]->out sram[412]->outb sram[413]->out sram[413]->outb sram[414]->out sram[414]->outb sram[415]->out sram[415]->outb gvdd_mux_2level_size50[25] 0 mux_2level_size50
***** SRAM bits for MUX[25], level=2, select_path_id=0. *****
*****1000000010000000*****
Xsram[400] sram->in sram[400]->out sram[400]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[400]->out) 0
.nodeset V(sram[400]->outb) vsp
Xsram[401] sram->in sram[401]->out sram[401]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[401]->out) 0
.nodeset V(sram[401]->outb) vsp
Xsram[402] sram->in sram[402]->out sram[402]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[402]->out) 0
.nodeset V(sram[402]->outb) vsp
Xsram[403] sram->in sram[403]->out sram[403]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[403]->out) 0
.nodeset V(sram[403]->outb) vsp
Xsram[404] sram->in sram[404]->out sram[404]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[404]->out) 0
.nodeset V(sram[404]->outb) vsp
Xsram[405] sram->in sram[405]->out sram[405]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[405]->out) 0
.nodeset V(sram[405]->outb) vsp
Xsram[406] sram->in sram[406]->out sram[406]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[406]->out) 0
.nodeset V(sram[406]->outb) vsp
Xsram[407] sram->in sram[407]->out sram[407]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[407]->out) 0
.nodeset V(sram[407]->outb) vsp
Xsram[408] sram->in sram[408]->out sram[408]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[408]->out) 0
.nodeset V(sram[408]->outb) vsp
Xsram[409] sram->in sram[409]->out sram[409]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[409]->out) 0
.nodeset V(sram[409]->outb) vsp
Xsram[410] sram->in sram[410]->out sram[410]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[410]->out) 0
.nodeset V(sram[410]->outb) vsp
Xsram[411] sram->in sram[411]->out sram[411]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[411]->out) 0
.nodeset V(sram[411]->outb) vsp
Xsram[412] sram->in sram[412]->out sram[412]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[412]->out) 0
.nodeset V(sram[412]->outb) vsp
Xsram[413] sram->in sram[413]->out sram[413]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[413]->out) 0
.nodeset V(sram[413]->outb) vsp
Xsram[414] sram->in sram[414]->out sram[414]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[414]->out) 0
.nodeset V(sram[414]->outb) vsp
Xsram[415] sram->in sram[415]->out sram[415]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[415]->out) 0
.nodeset V(sram[415]->outb) vsp
***** Signal mux_2level_size50[25]->in[0] density = 0, probability=0.*****
Vmux_2level_size50[25]->in[0] mux_2level_size50[25]->in[0] 0
+  0
***** Signal mux_2level_size50[25]->in[1] density = 0, probability=0.*****
Vmux_2level_size50[25]->in[1] mux_2level_size50[25]->in[1] 0
+  0
***** Signal mux_2level_size50[25]->in[2] density = 0, probability=0.*****
Vmux_2level_size50[25]->in[2] mux_2level_size50[25]->in[2] 0
+  0
***** Signal mux_2level_size50[25]->in[3] density = 0, probability=0.*****
Vmux_2level_size50[25]->in[3] mux_2level_size50[25]->in[3] 0
+  0
***** Signal mux_2level_size50[25]->in[4] density = 0, probability=0.*****
Vmux_2level_size50[25]->in[4] mux_2level_size50[25]->in[4] 0
+  0
***** Signal mux_2level_size50[25]->in[5] density = 0, probability=0.*****
Vmux_2level_size50[25]->in[5] mux_2level_size50[25]->in[5] 0
+  0
***** Signal mux_2level_size50[25]->in[6] density = 0, probability=0.*****
Vmux_2level_size50[25]->in[6] mux_2level_size50[25]->in[6] 0
+  0
***** Signal mux_2level_size50[25]->in[7] density = 0, probability=0.*****
Vmux_2level_size50[25]->in[7] mux_2level_size50[25]->in[7] 0
+  0
***** Signal mux_2level_size50[25]->in[8] density = 0, probability=0.*****
Vmux_2level_size50[25]->in[8] mux_2level_size50[25]->in[8] 0
+  0
***** Signal mux_2level_size50[25]->in[9] density = 0, probability=0.*****
Vmux_2level_size50[25]->in[9] mux_2level_size50[25]->in[9] 0
+  0
***** Signal mux_2level_size50[25]->in[10] density = 0, probability=0.*****
Vmux_2level_size50[25]->in[10] mux_2level_size50[25]->in[10] 0
+  0
***** Signal mux_2level_size50[25]->in[11] density = 0, probability=0.*****
Vmux_2level_size50[25]->in[11] mux_2level_size50[25]->in[11] 0
+  0
***** Signal mux_2level_size50[25]->in[12] density = 0, probability=0.*****
Vmux_2level_size50[25]->in[12] mux_2level_size50[25]->in[12] 0
+  0
***** Signal mux_2level_size50[25]->in[13] density = 0, probability=0.*****
Vmux_2level_size50[25]->in[13] mux_2level_size50[25]->in[13] 0
+  0
***** Signal mux_2level_size50[25]->in[14] density = 0, probability=0.*****
Vmux_2level_size50[25]->in[14] mux_2level_size50[25]->in[14] 0
+  0
***** Signal mux_2level_size50[25]->in[15] density = 0, probability=0.*****
Vmux_2level_size50[25]->in[15] mux_2level_size50[25]->in[15] 0
+  0
***** Signal mux_2level_size50[25]->in[16] density = 0, probability=0.*****
Vmux_2level_size50[25]->in[16] mux_2level_size50[25]->in[16] 0
+  0
***** Signal mux_2level_size50[25]->in[17] density = 0, probability=0.*****
Vmux_2level_size50[25]->in[17] mux_2level_size50[25]->in[17] 0
+  0
***** Signal mux_2level_size50[25]->in[18] density = 0, probability=0.*****
Vmux_2level_size50[25]->in[18] mux_2level_size50[25]->in[18] 0
+  0
***** Signal mux_2level_size50[25]->in[19] density = 0, probability=0.*****
Vmux_2level_size50[25]->in[19] mux_2level_size50[25]->in[19] 0
+  0
***** Signal mux_2level_size50[25]->in[20] density = 0, probability=0.*****
Vmux_2level_size50[25]->in[20] mux_2level_size50[25]->in[20] 0
+  0
***** Signal mux_2level_size50[25]->in[21] density = 0, probability=0.*****
Vmux_2level_size50[25]->in[21] mux_2level_size50[25]->in[21] 0
+  0
***** Signal mux_2level_size50[25]->in[22] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[25]->in[22] mux_2level_size50[25]->in[22] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[25]->in[23] density = 0, probability=0.*****
Vmux_2level_size50[25]->in[23] mux_2level_size50[25]->in[23] 0
+  0
***** Signal mux_2level_size50[25]->in[24] density = 0, probability=0.*****
Vmux_2level_size50[25]->in[24] mux_2level_size50[25]->in[24] 0
+  0
***** Signal mux_2level_size50[25]->in[25] density = 0, probability=0.*****
Vmux_2level_size50[25]->in[25] mux_2level_size50[25]->in[25] 0
+  0
***** Signal mux_2level_size50[25]->in[26] density = 0, probability=0.*****
Vmux_2level_size50[25]->in[26] mux_2level_size50[25]->in[26] 0
+  0
***** Signal mux_2level_size50[25]->in[27] density = 0, probability=0.*****
Vmux_2level_size50[25]->in[27] mux_2level_size50[25]->in[27] 0
+  0
***** Signal mux_2level_size50[25]->in[28] density = 0, probability=0.*****
Vmux_2level_size50[25]->in[28] mux_2level_size50[25]->in[28] 0
+  0
***** Signal mux_2level_size50[25]->in[29] density = 0, probability=0.*****
Vmux_2level_size50[25]->in[29] mux_2level_size50[25]->in[29] 0
+  0
***** Signal mux_2level_size50[25]->in[30] density = 0, probability=0.*****
Vmux_2level_size50[25]->in[30] mux_2level_size50[25]->in[30] 0
+  0
***** Signal mux_2level_size50[25]->in[31] density = 0, probability=0.*****
Vmux_2level_size50[25]->in[31] mux_2level_size50[25]->in[31] 0
+  0
***** Signal mux_2level_size50[25]->in[32] density = 0, probability=0.*****
Vmux_2level_size50[25]->in[32] mux_2level_size50[25]->in[32] 0
+  0
***** Signal mux_2level_size50[25]->in[33] density = 0, probability=0.*****
Vmux_2level_size50[25]->in[33] mux_2level_size50[25]->in[33] 0
+  0
***** Signal mux_2level_size50[25]->in[34] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[25]->in[34] mux_2level_size50[25]->in[34] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[25]->in[35] density = 0, probability=0.*****
Vmux_2level_size50[25]->in[35] mux_2level_size50[25]->in[35] 0
+  0
***** Signal mux_2level_size50[25]->in[36] density = 0, probability=0.*****
Vmux_2level_size50[25]->in[36] mux_2level_size50[25]->in[36] 0
+  0
***** Signal mux_2level_size50[25]->in[37] density = 0, probability=0.*****
Vmux_2level_size50[25]->in[37] mux_2level_size50[25]->in[37] 0
+  0
***** Signal mux_2level_size50[25]->in[38] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[25]->in[38] mux_2level_size50[25]->in[38] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[25]->in[39] density = 0, probability=0.*****
Vmux_2level_size50[25]->in[39] mux_2level_size50[25]->in[39] 0
+  0
***** Signal mux_2level_size50[25]->in[40] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[25]->in[40] mux_2level_size50[25]->in[40] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[25]->in[41] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[25]->in[41] mux_2level_size50[25]->in[41] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[25]->in[42] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[25]->in[42] mux_2level_size50[25]->in[42] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[25]->in[43] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[25]->in[43] mux_2level_size50[25]->in[43] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[25]->in[44] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[25]->in[44] mux_2level_size50[25]->in[44] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[25]->in[45] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[25]->in[45] mux_2level_size50[25]->in[45] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[25]->in[46] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[25]->in[46] mux_2level_size50[25]->in[46] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[25]->in[47] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[25]->in[47] mux_2level_size50[25]->in[47] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[25]->in[48] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[25]->in[48] mux_2level_size50[25]->in[48] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[25]->in[49] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[25]->in[49] mux_2level_size50[25]->in[49] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
Vgvdd_mux_2level_size50[25] gvdd_mux_2level_size50[25] 0 vsp
***** Measurements *****
***** Rise delay *****
.meas tran delay_rise_idle_mux50[25]_in[1]_crossbar trig v(mux_2level_size50[25]->in[0]) val='input_thres_pct_rise*vsp' rise=1 td='clock_period'
+          targ v(mux_2level_size50[25]->out) val='output_thres_pct_rise*vsp' rise=1 td='clock_period'
***** Fall delay *****
.meas tran delay_fall_idle_mux50[25]_in[1]_crossbar trig v(mux_2level_size50[25]->in[0]) val='input_thres_pct_fall*vsp' fall=1 td='clock_period'
+          targ v(mux_2level_size50[25]->out) val='output_thres_pct_fall*vsp' fall=1 td='clock_period'
***** Rise timing period *****
.meas start_rise_idle_mux50[25]_in[1]_crossbar when v(mux_2level_size50[25]->in[0])='slew_lower_thres_pct_rise*vsp' rise=1 td='clock_period'
.meas tran switch_rise_idle_mux50[25]_in[1]_crossbar trig v(mux_2level_size50[25]->in[0]) val='slew_lower_thres_pct_rise*vsp' rise=1 td='clock_period'
+          targ v(mux_2level_size50[25]->out) val='slew_upper_thres_pct_rise*vsp' rise=1 td='clock_period'
***** Fall timing period *****
.meas start_fall_idle_mux50[25]_in[1]_crossbar when v(mux_2level_size50[25]->in[0])='slew_lower_thres_pct_fall*vsp' fall=1 td='clock_period'
.meas tran switch_fall_idle_mux50[25]_in[1]_crossbar trig v(mux_2level_size50[25]->in[0]) val='slew_lower_thres_pct_fall*vsp' fall=1 td='clock_period'
+          targ v(mux_2level_size50[25]->out) val='slew_upper_thres_pct_fall*vsp' fall=1 td='clock_period'
***** Leakage Power Measurement *****
.meas tran mux_2level_size50[25]_leakage_power avg p(Vgvdd_mux_2level_size50[25]) from=0 to='clock_period'
.meas tran leakage_idle_mux50[25]_in[1]_crossbar param='mux_2level_size50[25]_leakage_power'
***** Dynamic Power Measurement *****
.meas tran mux_2level_size50[25]_dynamic_power avg p(Vgvdd_mux_2level_size50[25]) from='clock_period' to='6*clock_period'
.meas tran mux_2level_size50[25]_energy_per_cycle param='mux_2level_size50[25]_dynamic_power*clock_period'
.meas tran dynamic_power_idle_mux50[25]_in[1]_crossbar  param='mux_2level_size50[25]_dynamic_power'
.meas tran energy_per_cycle_idle_mux50[25]_in[1]_crossbar  param='dynamic_power_idle_mux50[25]_in[1]_crossbar*clock_period'
.meas tran dynamic_rise_idle_mux50[25]_in[1]_crossbar avg p(Vgvdd_mux_2level_size50[25]) from='start_rise_idle_mux50[25]_in[1]_crossbar' to='start_rise_idle_mux50[25]_in[1]_crossbar+switch_rise_idle_mux50[25]_in[1]_crossbar'
.meas tran dynamic_fall_idle_mux50[25]_in[1]_crossbar avg p(Vgvdd_mux_2level_size50[25]) from='start_fall_idle_mux50[25]_in[1]_crossbar' to='start_fall_idle_mux50[25]_in[1]_crossbar+switch_fall_idle_mux50[25]_in[1]_crossbar'
.meas tran sum_leakage_power_mux[0to25]
+          param='sum_leakage_power_mux[0to24]+leakage_idle_mux50[25]_in[1]_crossbar'
.meas tran sum_energy_per_cycle_mux[0to25]
+          param='sum_energy_per_cycle_mux[0to24]+energy_per_cycle_idle_mux50[25]_in[1]_crossbar'
Xload_inv[25]_no0 mux_2level_size50[25]->out mux_2level_size50[25]->out_out[0] gvdd_load 0 inv size=5
.meas tran sum_leakage_power_pb_mux[0to25]
+          param='sum_leakage_power_pb_mux[0to24]+leakage_idle_mux50[25]_in[1]_crossbar'
.meas tran sum_energy_per_cycle_pb_mux[0to25]
+          param='sum_energy_per_cycle_pb_mux[0to24]+energy_per_cycle_idle_mux50[25]_in[1]_crossbar'
Xmux_2level_size50[26] mux_2level_size50[26]->in[0] mux_2level_size50[26]->in[1] mux_2level_size50[26]->in[2] mux_2level_size50[26]->in[3] mux_2level_size50[26]->in[4] mux_2level_size50[26]->in[5] mux_2level_size50[26]->in[6] mux_2level_size50[26]->in[7] mux_2level_size50[26]->in[8] mux_2level_size50[26]->in[9] mux_2level_size50[26]->in[10] mux_2level_size50[26]->in[11] mux_2level_size50[26]->in[12] mux_2level_size50[26]->in[13] mux_2level_size50[26]->in[14] mux_2level_size50[26]->in[15] mux_2level_size50[26]->in[16] mux_2level_size50[26]->in[17] mux_2level_size50[26]->in[18] mux_2level_size50[26]->in[19] mux_2level_size50[26]->in[20] mux_2level_size50[26]->in[21] mux_2level_size50[26]->in[22] mux_2level_size50[26]->in[23] mux_2level_size50[26]->in[24] mux_2level_size50[26]->in[25] mux_2level_size50[26]->in[26] mux_2level_size50[26]->in[27] mux_2level_size50[26]->in[28] mux_2level_size50[26]->in[29] mux_2level_size50[26]->in[30] mux_2level_size50[26]->in[31] mux_2level_size50[26]->in[32] mux_2level_size50[26]->in[33] mux_2level_size50[26]->in[34] mux_2level_size50[26]->in[35] mux_2level_size50[26]->in[36] mux_2level_size50[26]->in[37] mux_2level_size50[26]->in[38] mux_2level_size50[26]->in[39] mux_2level_size50[26]->in[40] mux_2level_size50[26]->in[41] mux_2level_size50[26]->in[42] mux_2level_size50[26]->in[43] mux_2level_size50[26]->in[44] mux_2level_size50[26]->in[45] mux_2level_size50[26]->in[46] mux_2level_size50[26]->in[47] mux_2level_size50[26]->in[48] mux_2level_size50[26]->in[49] mux_2level_size50[26]->out sram[416]->outb sram[416]->out sram[417]->out sram[417]->outb sram[418]->out sram[418]->outb sram[419]->out sram[419]->outb sram[420]->out sram[420]->outb sram[421]->out sram[421]->outb sram[422]->out sram[422]->outb sram[423]->out sram[423]->outb sram[424]->outb sram[424]->out sram[425]->out sram[425]->outb sram[426]->out sram[426]->outb sram[427]->out sram[427]->outb sram[428]->out sram[428]->outb sram[429]->out sram[429]->outb sram[430]->out sram[430]->outb sram[431]->out sram[431]->outb gvdd_mux_2level_size50[26] 0 mux_2level_size50
***** SRAM bits for MUX[26], level=2, select_path_id=0. *****
*****1000000010000000*****
Xsram[416] sram->in sram[416]->out sram[416]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[416]->out) 0
.nodeset V(sram[416]->outb) vsp
Xsram[417] sram->in sram[417]->out sram[417]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[417]->out) 0
.nodeset V(sram[417]->outb) vsp
Xsram[418] sram->in sram[418]->out sram[418]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[418]->out) 0
.nodeset V(sram[418]->outb) vsp
Xsram[419] sram->in sram[419]->out sram[419]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[419]->out) 0
.nodeset V(sram[419]->outb) vsp
Xsram[420] sram->in sram[420]->out sram[420]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[420]->out) 0
.nodeset V(sram[420]->outb) vsp
Xsram[421] sram->in sram[421]->out sram[421]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[421]->out) 0
.nodeset V(sram[421]->outb) vsp
Xsram[422] sram->in sram[422]->out sram[422]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[422]->out) 0
.nodeset V(sram[422]->outb) vsp
Xsram[423] sram->in sram[423]->out sram[423]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[423]->out) 0
.nodeset V(sram[423]->outb) vsp
Xsram[424] sram->in sram[424]->out sram[424]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[424]->out) 0
.nodeset V(sram[424]->outb) vsp
Xsram[425] sram->in sram[425]->out sram[425]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[425]->out) 0
.nodeset V(sram[425]->outb) vsp
Xsram[426] sram->in sram[426]->out sram[426]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[426]->out) 0
.nodeset V(sram[426]->outb) vsp
Xsram[427] sram->in sram[427]->out sram[427]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[427]->out) 0
.nodeset V(sram[427]->outb) vsp
Xsram[428] sram->in sram[428]->out sram[428]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[428]->out) 0
.nodeset V(sram[428]->outb) vsp
Xsram[429] sram->in sram[429]->out sram[429]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[429]->out) 0
.nodeset V(sram[429]->outb) vsp
Xsram[430] sram->in sram[430]->out sram[430]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[430]->out) 0
.nodeset V(sram[430]->outb) vsp
Xsram[431] sram->in sram[431]->out sram[431]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[431]->out) 0
.nodeset V(sram[431]->outb) vsp
***** Signal mux_2level_size50[26]->in[0] density = 0, probability=0.*****
Vmux_2level_size50[26]->in[0] mux_2level_size50[26]->in[0] 0
+  0
***** Signal mux_2level_size50[26]->in[1] density = 0, probability=0.*****
Vmux_2level_size50[26]->in[1] mux_2level_size50[26]->in[1] 0
+  0
***** Signal mux_2level_size50[26]->in[2] density = 0, probability=0.*****
Vmux_2level_size50[26]->in[2] mux_2level_size50[26]->in[2] 0
+  0
***** Signal mux_2level_size50[26]->in[3] density = 0, probability=0.*****
Vmux_2level_size50[26]->in[3] mux_2level_size50[26]->in[3] 0
+  0
***** Signal mux_2level_size50[26]->in[4] density = 0, probability=0.*****
Vmux_2level_size50[26]->in[4] mux_2level_size50[26]->in[4] 0
+  0
***** Signal mux_2level_size50[26]->in[5] density = 0, probability=0.*****
Vmux_2level_size50[26]->in[5] mux_2level_size50[26]->in[5] 0
+  0
***** Signal mux_2level_size50[26]->in[6] density = 0, probability=0.*****
Vmux_2level_size50[26]->in[6] mux_2level_size50[26]->in[6] 0
+  0
***** Signal mux_2level_size50[26]->in[7] density = 0, probability=0.*****
Vmux_2level_size50[26]->in[7] mux_2level_size50[26]->in[7] 0
+  0
***** Signal mux_2level_size50[26]->in[8] density = 0, probability=0.*****
Vmux_2level_size50[26]->in[8] mux_2level_size50[26]->in[8] 0
+  0
***** Signal mux_2level_size50[26]->in[9] density = 0, probability=0.*****
Vmux_2level_size50[26]->in[9] mux_2level_size50[26]->in[9] 0
+  0
***** Signal mux_2level_size50[26]->in[10] density = 0, probability=0.*****
Vmux_2level_size50[26]->in[10] mux_2level_size50[26]->in[10] 0
+  0
***** Signal mux_2level_size50[26]->in[11] density = 0, probability=0.*****
Vmux_2level_size50[26]->in[11] mux_2level_size50[26]->in[11] 0
+  0
***** Signal mux_2level_size50[26]->in[12] density = 0, probability=0.*****
Vmux_2level_size50[26]->in[12] mux_2level_size50[26]->in[12] 0
+  0
***** Signal mux_2level_size50[26]->in[13] density = 0, probability=0.*****
Vmux_2level_size50[26]->in[13] mux_2level_size50[26]->in[13] 0
+  0
***** Signal mux_2level_size50[26]->in[14] density = 0, probability=0.*****
Vmux_2level_size50[26]->in[14] mux_2level_size50[26]->in[14] 0
+  0
***** Signal mux_2level_size50[26]->in[15] density = 0, probability=0.*****
Vmux_2level_size50[26]->in[15] mux_2level_size50[26]->in[15] 0
+  0
***** Signal mux_2level_size50[26]->in[16] density = 0, probability=0.*****
Vmux_2level_size50[26]->in[16] mux_2level_size50[26]->in[16] 0
+  0
***** Signal mux_2level_size50[26]->in[17] density = 0, probability=0.*****
Vmux_2level_size50[26]->in[17] mux_2level_size50[26]->in[17] 0
+  0
***** Signal mux_2level_size50[26]->in[18] density = 0, probability=0.*****
Vmux_2level_size50[26]->in[18] mux_2level_size50[26]->in[18] 0
+  0
***** Signal mux_2level_size50[26]->in[19] density = 0, probability=0.*****
Vmux_2level_size50[26]->in[19] mux_2level_size50[26]->in[19] 0
+  0
***** Signal mux_2level_size50[26]->in[20] density = 0, probability=0.*****
Vmux_2level_size50[26]->in[20] mux_2level_size50[26]->in[20] 0
+  0
***** Signal mux_2level_size50[26]->in[21] density = 0, probability=0.*****
Vmux_2level_size50[26]->in[21] mux_2level_size50[26]->in[21] 0
+  0
***** Signal mux_2level_size50[26]->in[22] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[26]->in[22] mux_2level_size50[26]->in[22] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[26]->in[23] density = 0, probability=0.*****
Vmux_2level_size50[26]->in[23] mux_2level_size50[26]->in[23] 0
+  0
***** Signal mux_2level_size50[26]->in[24] density = 0, probability=0.*****
Vmux_2level_size50[26]->in[24] mux_2level_size50[26]->in[24] 0
+  0
***** Signal mux_2level_size50[26]->in[25] density = 0, probability=0.*****
Vmux_2level_size50[26]->in[25] mux_2level_size50[26]->in[25] 0
+  0
***** Signal mux_2level_size50[26]->in[26] density = 0, probability=0.*****
Vmux_2level_size50[26]->in[26] mux_2level_size50[26]->in[26] 0
+  0
***** Signal mux_2level_size50[26]->in[27] density = 0, probability=0.*****
Vmux_2level_size50[26]->in[27] mux_2level_size50[26]->in[27] 0
+  0
***** Signal mux_2level_size50[26]->in[28] density = 0, probability=0.*****
Vmux_2level_size50[26]->in[28] mux_2level_size50[26]->in[28] 0
+  0
***** Signal mux_2level_size50[26]->in[29] density = 0, probability=0.*****
Vmux_2level_size50[26]->in[29] mux_2level_size50[26]->in[29] 0
+  0
***** Signal mux_2level_size50[26]->in[30] density = 0, probability=0.*****
Vmux_2level_size50[26]->in[30] mux_2level_size50[26]->in[30] 0
+  0
***** Signal mux_2level_size50[26]->in[31] density = 0, probability=0.*****
Vmux_2level_size50[26]->in[31] mux_2level_size50[26]->in[31] 0
+  0
***** Signal mux_2level_size50[26]->in[32] density = 0, probability=0.*****
Vmux_2level_size50[26]->in[32] mux_2level_size50[26]->in[32] 0
+  0
***** Signal mux_2level_size50[26]->in[33] density = 0, probability=0.*****
Vmux_2level_size50[26]->in[33] mux_2level_size50[26]->in[33] 0
+  0
***** Signal mux_2level_size50[26]->in[34] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[26]->in[34] mux_2level_size50[26]->in[34] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[26]->in[35] density = 0, probability=0.*****
Vmux_2level_size50[26]->in[35] mux_2level_size50[26]->in[35] 0
+  0
***** Signal mux_2level_size50[26]->in[36] density = 0, probability=0.*****
Vmux_2level_size50[26]->in[36] mux_2level_size50[26]->in[36] 0
+  0
***** Signal mux_2level_size50[26]->in[37] density = 0, probability=0.*****
Vmux_2level_size50[26]->in[37] mux_2level_size50[26]->in[37] 0
+  0
***** Signal mux_2level_size50[26]->in[38] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[26]->in[38] mux_2level_size50[26]->in[38] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[26]->in[39] density = 0, probability=0.*****
Vmux_2level_size50[26]->in[39] mux_2level_size50[26]->in[39] 0
+  0
***** Signal mux_2level_size50[26]->in[40] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[26]->in[40] mux_2level_size50[26]->in[40] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[26]->in[41] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[26]->in[41] mux_2level_size50[26]->in[41] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[26]->in[42] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[26]->in[42] mux_2level_size50[26]->in[42] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[26]->in[43] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[26]->in[43] mux_2level_size50[26]->in[43] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[26]->in[44] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[26]->in[44] mux_2level_size50[26]->in[44] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[26]->in[45] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[26]->in[45] mux_2level_size50[26]->in[45] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[26]->in[46] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[26]->in[46] mux_2level_size50[26]->in[46] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[26]->in[47] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[26]->in[47] mux_2level_size50[26]->in[47] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[26]->in[48] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[26]->in[48] mux_2level_size50[26]->in[48] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[26]->in[49] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[26]->in[49] mux_2level_size50[26]->in[49] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
Vgvdd_mux_2level_size50[26] gvdd_mux_2level_size50[26] 0 vsp
***** Measurements *****
***** Rise delay *****
.meas tran delay_rise_idle_mux50[26]_in[2]_crossbar trig v(mux_2level_size50[26]->in[0]) val='input_thres_pct_rise*vsp' rise=1 td='clock_period'
+          targ v(mux_2level_size50[26]->out) val='output_thres_pct_rise*vsp' rise=1 td='clock_period'
***** Fall delay *****
.meas tran delay_fall_idle_mux50[26]_in[2]_crossbar trig v(mux_2level_size50[26]->in[0]) val='input_thres_pct_fall*vsp' fall=1 td='clock_period'
+          targ v(mux_2level_size50[26]->out) val='output_thres_pct_fall*vsp' fall=1 td='clock_period'
***** Rise timing period *****
.meas start_rise_idle_mux50[26]_in[2]_crossbar when v(mux_2level_size50[26]->in[0])='slew_lower_thres_pct_rise*vsp' rise=1 td='clock_period'
.meas tran switch_rise_idle_mux50[26]_in[2]_crossbar trig v(mux_2level_size50[26]->in[0]) val='slew_lower_thres_pct_rise*vsp' rise=1 td='clock_period'
+          targ v(mux_2level_size50[26]->out) val='slew_upper_thres_pct_rise*vsp' rise=1 td='clock_period'
***** Fall timing period *****
.meas start_fall_idle_mux50[26]_in[2]_crossbar when v(mux_2level_size50[26]->in[0])='slew_lower_thres_pct_fall*vsp' fall=1 td='clock_period'
.meas tran switch_fall_idle_mux50[26]_in[2]_crossbar trig v(mux_2level_size50[26]->in[0]) val='slew_lower_thres_pct_fall*vsp' fall=1 td='clock_period'
+          targ v(mux_2level_size50[26]->out) val='slew_upper_thres_pct_fall*vsp' fall=1 td='clock_period'
***** Leakage Power Measurement *****
.meas tran mux_2level_size50[26]_leakage_power avg p(Vgvdd_mux_2level_size50[26]) from=0 to='clock_period'
.meas tran leakage_idle_mux50[26]_in[2]_crossbar param='mux_2level_size50[26]_leakage_power'
***** Dynamic Power Measurement *****
.meas tran mux_2level_size50[26]_dynamic_power avg p(Vgvdd_mux_2level_size50[26]) from='clock_period' to='6*clock_period'
.meas tran mux_2level_size50[26]_energy_per_cycle param='mux_2level_size50[26]_dynamic_power*clock_period'
.meas tran dynamic_power_idle_mux50[26]_in[2]_crossbar  param='mux_2level_size50[26]_dynamic_power'
.meas tran energy_per_cycle_idle_mux50[26]_in[2]_crossbar  param='dynamic_power_idle_mux50[26]_in[2]_crossbar*clock_period'
.meas tran dynamic_rise_idle_mux50[26]_in[2]_crossbar avg p(Vgvdd_mux_2level_size50[26]) from='start_rise_idle_mux50[26]_in[2]_crossbar' to='start_rise_idle_mux50[26]_in[2]_crossbar+switch_rise_idle_mux50[26]_in[2]_crossbar'
.meas tran dynamic_fall_idle_mux50[26]_in[2]_crossbar avg p(Vgvdd_mux_2level_size50[26]) from='start_fall_idle_mux50[26]_in[2]_crossbar' to='start_fall_idle_mux50[26]_in[2]_crossbar+switch_fall_idle_mux50[26]_in[2]_crossbar'
.meas tran sum_leakage_power_mux[0to26]
+          param='sum_leakage_power_mux[0to25]+leakage_idle_mux50[26]_in[2]_crossbar'
.meas tran sum_energy_per_cycle_mux[0to26]
+          param='sum_energy_per_cycle_mux[0to25]+energy_per_cycle_idle_mux50[26]_in[2]_crossbar'
Xload_inv[26]_no0 mux_2level_size50[26]->out mux_2level_size50[26]->out_out[0] gvdd_load 0 inv size=5
.meas tran sum_leakage_power_pb_mux[0to26]
+          param='sum_leakage_power_pb_mux[0to25]+leakage_idle_mux50[26]_in[2]_crossbar'
.meas tran sum_energy_per_cycle_pb_mux[0to26]
+          param='sum_energy_per_cycle_pb_mux[0to25]+energy_per_cycle_idle_mux50[26]_in[2]_crossbar'
Xmux_2level_size50[27] mux_2level_size50[27]->in[0] mux_2level_size50[27]->in[1] mux_2level_size50[27]->in[2] mux_2level_size50[27]->in[3] mux_2level_size50[27]->in[4] mux_2level_size50[27]->in[5] mux_2level_size50[27]->in[6] mux_2level_size50[27]->in[7] mux_2level_size50[27]->in[8] mux_2level_size50[27]->in[9] mux_2level_size50[27]->in[10] mux_2level_size50[27]->in[11] mux_2level_size50[27]->in[12] mux_2level_size50[27]->in[13] mux_2level_size50[27]->in[14] mux_2level_size50[27]->in[15] mux_2level_size50[27]->in[16] mux_2level_size50[27]->in[17] mux_2level_size50[27]->in[18] mux_2level_size50[27]->in[19] mux_2level_size50[27]->in[20] mux_2level_size50[27]->in[21] mux_2level_size50[27]->in[22] mux_2level_size50[27]->in[23] mux_2level_size50[27]->in[24] mux_2level_size50[27]->in[25] mux_2level_size50[27]->in[26] mux_2level_size50[27]->in[27] mux_2level_size50[27]->in[28] mux_2level_size50[27]->in[29] mux_2level_size50[27]->in[30] mux_2level_size50[27]->in[31] mux_2level_size50[27]->in[32] mux_2level_size50[27]->in[33] mux_2level_size50[27]->in[34] mux_2level_size50[27]->in[35] mux_2level_size50[27]->in[36] mux_2level_size50[27]->in[37] mux_2level_size50[27]->in[38] mux_2level_size50[27]->in[39] mux_2level_size50[27]->in[40] mux_2level_size50[27]->in[41] mux_2level_size50[27]->in[42] mux_2level_size50[27]->in[43] mux_2level_size50[27]->in[44] mux_2level_size50[27]->in[45] mux_2level_size50[27]->in[46] mux_2level_size50[27]->in[47] mux_2level_size50[27]->in[48] mux_2level_size50[27]->in[49] mux_2level_size50[27]->out sram[432]->outb sram[432]->out sram[433]->out sram[433]->outb sram[434]->out sram[434]->outb sram[435]->out sram[435]->outb sram[436]->out sram[436]->outb sram[437]->out sram[437]->outb sram[438]->out sram[438]->outb sram[439]->out sram[439]->outb sram[440]->outb sram[440]->out sram[441]->out sram[441]->outb sram[442]->out sram[442]->outb sram[443]->out sram[443]->outb sram[444]->out sram[444]->outb sram[445]->out sram[445]->outb sram[446]->out sram[446]->outb sram[447]->out sram[447]->outb gvdd_mux_2level_size50[27] 0 mux_2level_size50
***** SRAM bits for MUX[27], level=2, select_path_id=0. *****
*****1000000010000000*****
Xsram[432] sram->in sram[432]->out sram[432]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[432]->out) 0
.nodeset V(sram[432]->outb) vsp
Xsram[433] sram->in sram[433]->out sram[433]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[433]->out) 0
.nodeset V(sram[433]->outb) vsp
Xsram[434] sram->in sram[434]->out sram[434]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[434]->out) 0
.nodeset V(sram[434]->outb) vsp
Xsram[435] sram->in sram[435]->out sram[435]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[435]->out) 0
.nodeset V(sram[435]->outb) vsp
Xsram[436] sram->in sram[436]->out sram[436]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[436]->out) 0
.nodeset V(sram[436]->outb) vsp
Xsram[437] sram->in sram[437]->out sram[437]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[437]->out) 0
.nodeset V(sram[437]->outb) vsp
Xsram[438] sram->in sram[438]->out sram[438]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[438]->out) 0
.nodeset V(sram[438]->outb) vsp
Xsram[439] sram->in sram[439]->out sram[439]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[439]->out) 0
.nodeset V(sram[439]->outb) vsp
Xsram[440] sram->in sram[440]->out sram[440]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[440]->out) 0
.nodeset V(sram[440]->outb) vsp
Xsram[441] sram->in sram[441]->out sram[441]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[441]->out) 0
.nodeset V(sram[441]->outb) vsp
Xsram[442] sram->in sram[442]->out sram[442]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[442]->out) 0
.nodeset V(sram[442]->outb) vsp
Xsram[443] sram->in sram[443]->out sram[443]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[443]->out) 0
.nodeset V(sram[443]->outb) vsp
Xsram[444] sram->in sram[444]->out sram[444]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[444]->out) 0
.nodeset V(sram[444]->outb) vsp
Xsram[445] sram->in sram[445]->out sram[445]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[445]->out) 0
.nodeset V(sram[445]->outb) vsp
Xsram[446] sram->in sram[446]->out sram[446]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[446]->out) 0
.nodeset V(sram[446]->outb) vsp
Xsram[447] sram->in sram[447]->out sram[447]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[447]->out) 0
.nodeset V(sram[447]->outb) vsp
***** Signal mux_2level_size50[27]->in[0] density = 0, probability=0.*****
Vmux_2level_size50[27]->in[0] mux_2level_size50[27]->in[0] 0
+  0
***** Signal mux_2level_size50[27]->in[1] density = 0, probability=0.*****
Vmux_2level_size50[27]->in[1] mux_2level_size50[27]->in[1] 0
+  0
***** Signal mux_2level_size50[27]->in[2] density = 0, probability=0.*****
Vmux_2level_size50[27]->in[2] mux_2level_size50[27]->in[2] 0
+  0
***** Signal mux_2level_size50[27]->in[3] density = 0, probability=0.*****
Vmux_2level_size50[27]->in[3] mux_2level_size50[27]->in[3] 0
+  0
***** Signal mux_2level_size50[27]->in[4] density = 0, probability=0.*****
Vmux_2level_size50[27]->in[4] mux_2level_size50[27]->in[4] 0
+  0
***** Signal mux_2level_size50[27]->in[5] density = 0, probability=0.*****
Vmux_2level_size50[27]->in[5] mux_2level_size50[27]->in[5] 0
+  0
***** Signal mux_2level_size50[27]->in[6] density = 0, probability=0.*****
Vmux_2level_size50[27]->in[6] mux_2level_size50[27]->in[6] 0
+  0
***** Signal mux_2level_size50[27]->in[7] density = 0, probability=0.*****
Vmux_2level_size50[27]->in[7] mux_2level_size50[27]->in[7] 0
+  0
***** Signal mux_2level_size50[27]->in[8] density = 0, probability=0.*****
Vmux_2level_size50[27]->in[8] mux_2level_size50[27]->in[8] 0
+  0
***** Signal mux_2level_size50[27]->in[9] density = 0, probability=0.*****
Vmux_2level_size50[27]->in[9] mux_2level_size50[27]->in[9] 0
+  0
***** Signal mux_2level_size50[27]->in[10] density = 0, probability=0.*****
Vmux_2level_size50[27]->in[10] mux_2level_size50[27]->in[10] 0
+  0
***** Signal mux_2level_size50[27]->in[11] density = 0, probability=0.*****
Vmux_2level_size50[27]->in[11] mux_2level_size50[27]->in[11] 0
+  0
***** Signal mux_2level_size50[27]->in[12] density = 0, probability=0.*****
Vmux_2level_size50[27]->in[12] mux_2level_size50[27]->in[12] 0
+  0
***** Signal mux_2level_size50[27]->in[13] density = 0, probability=0.*****
Vmux_2level_size50[27]->in[13] mux_2level_size50[27]->in[13] 0
+  0
***** Signal mux_2level_size50[27]->in[14] density = 0, probability=0.*****
Vmux_2level_size50[27]->in[14] mux_2level_size50[27]->in[14] 0
+  0
***** Signal mux_2level_size50[27]->in[15] density = 0, probability=0.*****
Vmux_2level_size50[27]->in[15] mux_2level_size50[27]->in[15] 0
+  0
***** Signal mux_2level_size50[27]->in[16] density = 0, probability=0.*****
Vmux_2level_size50[27]->in[16] mux_2level_size50[27]->in[16] 0
+  0
***** Signal mux_2level_size50[27]->in[17] density = 0, probability=0.*****
Vmux_2level_size50[27]->in[17] mux_2level_size50[27]->in[17] 0
+  0
***** Signal mux_2level_size50[27]->in[18] density = 0, probability=0.*****
Vmux_2level_size50[27]->in[18] mux_2level_size50[27]->in[18] 0
+  0
***** Signal mux_2level_size50[27]->in[19] density = 0, probability=0.*****
Vmux_2level_size50[27]->in[19] mux_2level_size50[27]->in[19] 0
+  0
***** Signal mux_2level_size50[27]->in[20] density = 0, probability=0.*****
Vmux_2level_size50[27]->in[20] mux_2level_size50[27]->in[20] 0
+  0
***** Signal mux_2level_size50[27]->in[21] density = 0, probability=0.*****
Vmux_2level_size50[27]->in[21] mux_2level_size50[27]->in[21] 0
+  0
***** Signal mux_2level_size50[27]->in[22] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[27]->in[22] mux_2level_size50[27]->in[22] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[27]->in[23] density = 0, probability=0.*****
Vmux_2level_size50[27]->in[23] mux_2level_size50[27]->in[23] 0
+  0
***** Signal mux_2level_size50[27]->in[24] density = 0, probability=0.*****
Vmux_2level_size50[27]->in[24] mux_2level_size50[27]->in[24] 0
+  0
***** Signal mux_2level_size50[27]->in[25] density = 0, probability=0.*****
Vmux_2level_size50[27]->in[25] mux_2level_size50[27]->in[25] 0
+  0
***** Signal mux_2level_size50[27]->in[26] density = 0, probability=0.*****
Vmux_2level_size50[27]->in[26] mux_2level_size50[27]->in[26] 0
+  0
***** Signal mux_2level_size50[27]->in[27] density = 0, probability=0.*****
Vmux_2level_size50[27]->in[27] mux_2level_size50[27]->in[27] 0
+  0
***** Signal mux_2level_size50[27]->in[28] density = 0, probability=0.*****
Vmux_2level_size50[27]->in[28] mux_2level_size50[27]->in[28] 0
+  0
***** Signal mux_2level_size50[27]->in[29] density = 0, probability=0.*****
Vmux_2level_size50[27]->in[29] mux_2level_size50[27]->in[29] 0
+  0
***** Signal mux_2level_size50[27]->in[30] density = 0, probability=0.*****
Vmux_2level_size50[27]->in[30] mux_2level_size50[27]->in[30] 0
+  0
***** Signal mux_2level_size50[27]->in[31] density = 0, probability=0.*****
Vmux_2level_size50[27]->in[31] mux_2level_size50[27]->in[31] 0
+  0
***** Signal mux_2level_size50[27]->in[32] density = 0, probability=0.*****
Vmux_2level_size50[27]->in[32] mux_2level_size50[27]->in[32] 0
+  0
***** Signal mux_2level_size50[27]->in[33] density = 0, probability=0.*****
Vmux_2level_size50[27]->in[33] mux_2level_size50[27]->in[33] 0
+  0
***** Signal mux_2level_size50[27]->in[34] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[27]->in[34] mux_2level_size50[27]->in[34] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[27]->in[35] density = 0, probability=0.*****
Vmux_2level_size50[27]->in[35] mux_2level_size50[27]->in[35] 0
+  0
***** Signal mux_2level_size50[27]->in[36] density = 0, probability=0.*****
Vmux_2level_size50[27]->in[36] mux_2level_size50[27]->in[36] 0
+  0
***** Signal mux_2level_size50[27]->in[37] density = 0, probability=0.*****
Vmux_2level_size50[27]->in[37] mux_2level_size50[27]->in[37] 0
+  0
***** Signal mux_2level_size50[27]->in[38] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[27]->in[38] mux_2level_size50[27]->in[38] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[27]->in[39] density = 0, probability=0.*****
Vmux_2level_size50[27]->in[39] mux_2level_size50[27]->in[39] 0
+  0
***** Signal mux_2level_size50[27]->in[40] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[27]->in[40] mux_2level_size50[27]->in[40] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[27]->in[41] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[27]->in[41] mux_2level_size50[27]->in[41] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[27]->in[42] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[27]->in[42] mux_2level_size50[27]->in[42] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[27]->in[43] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[27]->in[43] mux_2level_size50[27]->in[43] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[27]->in[44] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[27]->in[44] mux_2level_size50[27]->in[44] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[27]->in[45] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[27]->in[45] mux_2level_size50[27]->in[45] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[27]->in[46] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[27]->in[46] mux_2level_size50[27]->in[46] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[27]->in[47] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[27]->in[47] mux_2level_size50[27]->in[47] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[27]->in[48] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[27]->in[48] mux_2level_size50[27]->in[48] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[27]->in[49] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[27]->in[49] mux_2level_size50[27]->in[49] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
Vgvdd_mux_2level_size50[27] gvdd_mux_2level_size50[27] 0 vsp
***** Measurements *****
***** Rise delay *****
.meas tran delay_rise_idle_mux50[27]_in[3]_crossbar trig v(mux_2level_size50[27]->in[0]) val='input_thres_pct_rise*vsp' rise=1 td='clock_period'
+          targ v(mux_2level_size50[27]->out) val='output_thres_pct_rise*vsp' rise=1 td='clock_period'
***** Fall delay *****
.meas tran delay_fall_idle_mux50[27]_in[3]_crossbar trig v(mux_2level_size50[27]->in[0]) val='input_thres_pct_fall*vsp' fall=1 td='clock_period'
+          targ v(mux_2level_size50[27]->out) val='output_thres_pct_fall*vsp' fall=1 td='clock_period'
***** Rise timing period *****
.meas start_rise_idle_mux50[27]_in[3]_crossbar when v(mux_2level_size50[27]->in[0])='slew_lower_thres_pct_rise*vsp' rise=1 td='clock_period'
.meas tran switch_rise_idle_mux50[27]_in[3]_crossbar trig v(mux_2level_size50[27]->in[0]) val='slew_lower_thres_pct_rise*vsp' rise=1 td='clock_period'
+          targ v(mux_2level_size50[27]->out) val='slew_upper_thres_pct_rise*vsp' rise=1 td='clock_period'
***** Fall timing period *****
.meas start_fall_idle_mux50[27]_in[3]_crossbar when v(mux_2level_size50[27]->in[0])='slew_lower_thres_pct_fall*vsp' fall=1 td='clock_period'
.meas tran switch_fall_idle_mux50[27]_in[3]_crossbar trig v(mux_2level_size50[27]->in[0]) val='slew_lower_thres_pct_fall*vsp' fall=1 td='clock_period'
+          targ v(mux_2level_size50[27]->out) val='slew_upper_thres_pct_fall*vsp' fall=1 td='clock_period'
***** Leakage Power Measurement *****
.meas tran mux_2level_size50[27]_leakage_power avg p(Vgvdd_mux_2level_size50[27]) from=0 to='clock_period'
.meas tran leakage_idle_mux50[27]_in[3]_crossbar param='mux_2level_size50[27]_leakage_power'
***** Dynamic Power Measurement *****
.meas tran mux_2level_size50[27]_dynamic_power avg p(Vgvdd_mux_2level_size50[27]) from='clock_period' to='6*clock_period'
.meas tran mux_2level_size50[27]_energy_per_cycle param='mux_2level_size50[27]_dynamic_power*clock_period'
.meas tran dynamic_power_idle_mux50[27]_in[3]_crossbar  param='mux_2level_size50[27]_dynamic_power'
.meas tran energy_per_cycle_idle_mux50[27]_in[3]_crossbar  param='dynamic_power_idle_mux50[27]_in[3]_crossbar*clock_period'
.meas tran dynamic_rise_idle_mux50[27]_in[3]_crossbar avg p(Vgvdd_mux_2level_size50[27]) from='start_rise_idle_mux50[27]_in[3]_crossbar' to='start_rise_idle_mux50[27]_in[3]_crossbar+switch_rise_idle_mux50[27]_in[3]_crossbar'
.meas tran dynamic_fall_idle_mux50[27]_in[3]_crossbar avg p(Vgvdd_mux_2level_size50[27]) from='start_fall_idle_mux50[27]_in[3]_crossbar' to='start_fall_idle_mux50[27]_in[3]_crossbar+switch_fall_idle_mux50[27]_in[3]_crossbar'
.meas tran sum_leakage_power_mux[0to27]
+          param='sum_leakage_power_mux[0to26]+leakage_idle_mux50[27]_in[3]_crossbar'
.meas tran sum_energy_per_cycle_mux[0to27]
+          param='sum_energy_per_cycle_mux[0to26]+energy_per_cycle_idle_mux50[27]_in[3]_crossbar'
Xload_inv[27]_no0 mux_2level_size50[27]->out mux_2level_size50[27]->out_out[0] gvdd_load 0 inv size=5
.meas tran sum_leakage_power_pb_mux[0to27]
+          param='sum_leakage_power_pb_mux[0to26]+leakage_idle_mux50[27]_in[3]_crossbar'
.meas tran sum_energy_per_cycle_pb_mux[0to27]
+          param='sum_energy_per_cycle_pb_mux[0to26]+energy_per_cycle_idle_mux50[27]_in[3]_crossbar'
Xmux_2level_size50[28] mux_2level_size50[28]->in[0] mux_2level_size50[28]->in[1] mux_2level_size50[28]->in[2] mux_2level_size50[28]->in[3] mux_2level_size50[28]->in[4] mux_2level_size50[28]->in[5] mux_2level_size50[28]->in[6] mux_2level_size50[28]->in[7] mux_2level_size50[28]->in[8] mux_2level_size50[28]->in[9] mux_2level_size50[28]->in[10] mux_2level_size50[28]->in[11] mux_2level_size50[28]->in[12] mux_2level_size50[28]->in[13] mux_2level_size50[28]->in[14] mux_2level_size50[28]->in[15] mux_2level_size50[28]->in[16] mux_2level_size50[28]->in[17] mux_2level_size50[28]->in[18] mux_2level_size50[28]->in[19] mux_2level_size50[28]->in[20] mux_2level_size50[28]->in[21] mux_2level_size50[28]->in[22] mux_2level_size50[28]->in[23] mux_2level_size50[28]->in[24] mux_2level_size50[28]->in[25] mux_2level_size50[28]->in[26] mux_2level_size50[28]->in[27] mux_2level_size50[28]->in[28] mux_2level_size50[28]->in[29] mux_2level_size50[28]->in[30] mux_2level_size50[28]->in[31] mux_2level_size50[28]->in[32] mux_2level_size50[28]->in[33] mux_2level_size50[28]->in[34] mux_2level_size50[28]->in[35] mux_2level_size50[28]->in[36] mux_2level_size50[28]->in[37] mux_2level_size50[28]->in[38] mux_2level_size50[28]->in[39] mux_2level_size50[28]->in[40] mux_2level_size50[28]->in[41] mux_2level_size50[28]->in[42] mux_2level_size50[28]->in[43] mux_2level_size50[28]->in[44] mux_2level_size50[28]->in[45] mux_2level_size50[28]->in[46] mux_2level_size50[28]->in[47] mux_2level_size50[28]->in[48] mux_2level_size50[28]->in[49] mux_2level_size50[28]->out sram[448]->outb sram[448]->out sram[449]->out sram[449]->outb sram[450]->out sram[450]->outb sram[451]->out sram[451]->outb sram[452]->out sram[452]->outb sram[453]->out sram[453]->outb sram[454]->out sram[454]->outb sram[455]->out sram[455]->outb sram[456]->outb sram[456]->out sram[457]->out sram[457]->outb sram[458]->out sram[458]->outb sram[459]->out sram[459]->outb sram[460]->out sram[460]->outb sram[461]->out sram[461]->outb sram[462]->out sram[462]->outb sram[463]->out sram[463]->outb gvdd_mux_2level_size50[28] 0 mux_2level_size50
***** SRAM bits for MUX[28], level=2, select_path_id=0. *****
*****1000000010000000*****
Xsram[448] sram->in sram[448]->out sram[448]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[448]->out) 0
.nodeset V(sram[448]->outb) vsp
Xsram[449] sram->in sram[449]->out sram[449]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[449]->out) 0
.nodeset V(sram[449]->outb) vsp
Xsram[450] sram->in sram[450]->out sram[450]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[450]->out) 0
.nodeset V(sram[450]->outb) vsp
Xsram[451] sram->in sram[451]->out sram[451]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[451]->out) 0
.nodeset V(sram[451]->outb) vsp
Xsram[452] sram->in sram[452]->out sram[452]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[452]->out) 0
.nodeset V(sram[452]->outb) vsp
Xsram[453] sram->in sram[453]->out sram[453]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[453]->out) 0
.nodeset V(sram[453]->outb) vsp
Xsram[454] sram->in sram[454]->out sram[454]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[454]->out) 0
.nodeset V(sram[454]->outb) vsp
Xsram[455] sram->in sram[455]->out sram[455]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[455]->out) 0
.nodeset V(sram[455]->outb) vsp
Xsram[456] sram->in sram[456]->out sram[456]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[456]->out) 0
.nodeset V(sram[456]->outb) vsp
Xsram[457] sram->in sram[457]->out sram[457]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[457]->out) 0
.nodeset V(sram[457]->outb) vsp
Xsram[458] sram->in sram[458]->out sram[458]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[458]->out) 0
.nodeset V(sram[458]->outb) vsp
Xsram[459] sram->in sram[459]->out sram[459]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[459]->out) 0
.nodeset V(sram[459]->outb) vsp
Xsram[460] sram->in sram[460]->out sram[460]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[460]->out) 0
.nodeset V(sram[460]->outb) vsp
Xsram[461] sram->in sram[461]->out sram[461]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[461]->out) 0
.nodeset V(sram[461]->outb) vsp
Xsram[462] sram->in sram[462]->out sram[462]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[462]->out) 0
.nodeset V(sram[462]->outb) vsp
Xsram[463] sram->in sram[463]->out sram[463]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[463]->out) 0
.nodeset V(sram[463]->outb) vsp
***** Signal mux_2level_size50[28]->in[0] density = 0, probability=0.*****
Vmux_2level_size50[28]->in[0] mux_2level_size50[28]->in[0] 0
+  0
***** Signal mux_2level_size50[28]->in[1] density = 0, probability=0.*****
Vmux_2level_size50[28]->in[1] mux_2level_size50[28]->in[1] 0
+  0
***** Signal mux_2level_size50[28]->in[2] density = 0, probability=0.*****
Vmux_2level_size50[28]->in[2] mux_2level_size50[28]->in[2] 0
+  0
***** Signal mux_2level_size50[28]->in[3] density = 0, probability=0.*****
Vmux_2level_size50[28]->in[3] mux_2level_size50[28]->in[3] 0
+  0
***** Signal mux_2level_size50[28]->in[4] density = 0, probability=0.*****
Vmux_2level_size50[28]->in[4] mux_2level_size50[28]->in[4] 0
+  0
***** Signal mux_2level_size50[28]->in[5] density = 0, probability=0.*****
Vmux_2level_size50[28]->in[5] mux_2level_size50[28]->in[5] 0
+  0
***** Signal mux_2level_size50[28]->in[6] density = 0, probability=0.*****
Vmux_2level_size50[28]->in[6] mux_2level_size50[28]->in[6] 0
+  0
***** Signal mux_2level_size50[28]->in[7] density = 0, probability=0.*****
Vmux_2level_size50[28]->in[7] mux_2level_size50[28]->in[7] 0
+  0
***** Signal mux_2level_size50[28]->in[8] density = 0, probability=0.*****
Vmux_2level_size50[28]->in[8] mux_2level_size50[28]->in[8] 0
+  0
***** Signal mux_2level_size50[28]->in[9] density = 0, probability=0.*****
Vmux_2level_size50[28]->in[9] mux_2level_size50[28]->in[9] 0
+  0
***** Signal mux_2level_size50[28]->in[10] density = 0, probability=0.*****
Vmux_2level_size50[28]->in[10] mux_2level_size50[28]->in[10] 0
+  0
***** Signal mux_2level_size50[28]->in[11] density = 0, probability=0.*****
Vmux_2level_size50[28]->in[11] mux_2level_size50[28]->in[11] 0
+  0
***** Signal mux_2level_size50[28]->in[12] density = 0, probability=0.*****
Vmux_2level_size50[28]->in[12] mux_2level_size50[28]->in[12] 0
+  0
***** Signal mux_2level_size50[28]->in[13] density = 0, probability=0.*****
Vmux_2level_size50[28]->in[13] mux_2level_size50[28]->in[13] 0
+  0
***** Signal mux_2level_size50[28]->in[14] density = 0, probability=0.*****
Vmux_2level_size50[28]->in[14] mux_2level_size50[28]->in[14] 0
+  0
***** Signal mux_2level_size50[28]->in[15] density = 0, probability=0.*****
Vmux_2level_size50[28]->in[15] mux_2level_size50[28]->in[15] 0
+  0
***** Signal mux_2level_size50[28]->in[16] density = 0, probability=0.*****
Vmux_2level_size50[28]->in[16] mux_2level_size50[28]->in[16] 0
+  0
***** Signal mux_2level_size50[28]->in[17] density = 0, probability=0.*****
Vmux_2level_size50[28]->in[17] mux_2level_size50[28]->in[17] 0
+  0
***** Signal mux_2level_size50[28]->in[18] density = 0, probability=0.*****
Vmux_2level_size50[28]->in[18] mux_2level_size50[28]->in[18] 0
+  0
***** Signal mux_2level_size50[28]->in[19] density = 0, probability=0.*****
Vmux_2level_size50[28]->in[19] mux_2level_size50[28]->in[19] 0
+  0
***** Signal mux_2level_size50[28]->in[20] density = 0, probability=0.*****
Vmux_2level_size50[28]->in[20] mux_2level_size50[28]->in[20] 0
+  0
***** Signal mux_2level_size50[28]->in[21] density = 0, probability=0.*****
Vmux_2level_size50[28]->in[21] mux_2level_size50[28]->in[21] 0
+  0
***** Signal mux_2level_size50[28]->in[22] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[28]->in[22] mux_2level_size50[28]->in[22] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[28]->in[23] density = 0, probability=0.*****
Vmux_2level_size50[28]->in[23] mux_2level_size50[28]->in[23] 0
+  0
***** Signal mux_2level_size50[28]->in[24] density = 0, probability=0.*****
Vmux_2level_size50[28]->in[24] mux_2level_size50[28]->in[24] 0
+  0
***** Signal mux_2level_size50[28]->in[25] density = 0, probability=0.*****
Vmux_2level_size50[28]->in[25] mux_2level_size50[28]->in[25] 0
+  0
***** Signal mux_2level_size50[28]->in[26] density = 0, probability=0.*****
Vmux_2level_size50[28]->in[26] mux_2level_size50[28]->in[26] 0
+  0
***** Signal mux_2level_size50[28]->in[27] density = 0, probability=0.*****
Vmux_2level_size50[28]->in[27] mux_2level_size50[28]->in[27] 0
+  0
***** Signal mux_2level_size50[28]->in[28] density = 0, probability=0.*****
Vmux_2level_size50[28]->in[28] mux_2level_size50[28]->in[28] 0
+  0
***** Signal mux_2level_size50[28]->in[29] density = 0, probability=0.*****
Vmux_2level_size50[28]->in[29] mux_2level_size50[28]->in[29] 0
+  0
***** Signal mux_2level_size50[28]->in[30] density = 0, probability=0.*****
Vmux_2level_size50[28]->in[30] mux_2level_size50[28]->in[30] 0
+  0
***** Signal mux_2level_size50[28]->in[31] density = 0, probability=0.*****
Vmux_2level_size50[28]->in[31] mux_2level_size50[28]->in[31] 0
+  0
***** Signal mux_2level_size50[28]->in[32] density = 0, probability=0.*****
Vmux_2level_size50[28]->in[32] mux_2level_size50[28]->in[32] 0
+  0
***** Signal mux_2level_size50[28]->in[33] density = 0, probability=0.*****
Vmux_2level_size50[28]->in[33] mux_2level_size50[28]->in[33] 0
+  0
***** Signal mux_2level_size50[28]->in[34] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[28]->in[34] mux_2level_size50[28]->in[34] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[28]->in[35] density = 0, probability=0.*****
Vmux_2level_size50[28]->in[35] mux_2level_size50[28]->in[35] 0
+  0
***** Signal mux_2level_size50[28]->in[36] density = 0, probability=0.*****
Vmux_2level_size50[28]->in[36] mux_2level_size50[28]->in[36] 0
+  0
***** Signal mux_2level_size50[28]->in[37] density = 0, probability=0.*****
Vmux_2level_size50[28]->in[37] mux_2level_size50[28]->in[37] 0
+  0
***** Signal mux_2level_size50[28]->in[38] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[28]->in[38] mux_2level_size50[28]->in[38] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[28]->in[39] density = 0, probability=0.*****
Vmux_2level_size50[28]->in[39] mux_2level_size50[28]->in[39] 0
+  0
***** Signal mux_2level_size50[28]->in[40] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[28]->in[40] mux_2level_size50[28]->in[40] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[28]->in[41] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[28]->in[41] mux_2level_size50[28]->in[41] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[28]->in[42] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[28]->in[42] mux_2level_size50[28]->in[42] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[28]->in[43] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[28]->in[43] mux_2level_size50[28]->in[43] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[28]->in[44] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[28]->in[44] mux_2level_size50[28]->in[44] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[28]->in[45] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[28]->in[45] mux_2level_size50[28]->in[45] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[28]->in[46] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[28]->in[46] mux_2level_size50[28]->in[46] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[28]->in[47] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[28]->in[47] mux_2level_size50[28]->in[47] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[28]->in[48] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[28]->in[48] mux_2level_size50[28]->in[48] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[28]->in[49] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[28]->in[49] mux_2level_size50[28]->in[49] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
Vgvdd_mux_2level_size50[28] gvdd_mux_2level_size50[28] 0 vsp
***** Measurements *****
***** Rise delay *****
.meas tran delay_rise_idle_mux50[28]_in[4]_crossbar trig v(mux_2level_size50[28]->in[0]) val='input_thres_pct_rise*vsp' rise=1 td='clock_period'
+          targ v(mux_2level_size50[28]->out) val='output_thres_pct_rise*vsp' rise=1 td='clock_period'
***** Fall delay *****
.meas tran delay_fall_idle_mux50[28]_in[4]_crossbar trig v(mux_2level_size50[28]->in[0]) val='input_thres_pct_fall*vsp' fall=1 td='clock_period'
+          targ v(mux_2level_size50[28]->out) val='output_thres_pct_fall*vsp' fall=1 td='clock_period'
***** Rise timing period *****
.meas start_rise_idle_mux50[28]_in[4]_crossbar when v(mux_2level_size50[28]->in[0])='slew_lower_thres_pct_rise*vsp' rise=1 td='clock_period'
.meas tran switch_rise_idle_mux50[28]_in[4]_crossbar trig v(mux_2level_size50[28]->in[0]) val='slew_lower_thres_pct_rise*vsp' rise=1 td='clock_period'
+          targ v(mux_2level_size50[28]->out) val='slew_upper_thres_pct_rise*vsp' rise=1 td='clock_period'
***** Fall timing period *****
.meas start_fall_idle_mux50[28]_in[4]_crossbar when v(mux_2level_size50[28]->in[0])='slew_lower_thres_pct_fall*vsp' fall=1 td='clock_period'
.meas tran switch_fall_idle_mux50[28]_in[4]_crossbar trig v(mux_2level_size50[28]->in[0]) val='slew_lower_thres_pct_fall*vsp' fall=1 td='clock_period'
+          targ v(mux_2level_size50[28]->out) val='slew_upper_thres_pct_fall*vsp' fall=1 td='clock_period'
***** Leakage Power Measurement *****
.meas tran mux_2level_size50[28]_leakage_power avg p(Vgvdd_mux_2level_size50[28]) from=0 to='clock_period'
.meas tran leakage_idle_mux50[28]_in[4]_crossbar param='mux_2level_size50[28]_leakage_power'
***** Dynamic Power Measurement *****
.meas tran mux_2level_size50[28]_dynamic_power avg p(Vgvdd_mux_2level_size50[28]) from='clock_period' to='6*clock_period'
.meas tran mux_2level_size50[28]_energy_per_cycle param='mux_2level_size50[28]_dynamic_power*clock_period'
.meas tran dynamic_power_idle_mux50[28]_in[4]_crossbar  param='mux_2level_size50[28]_dynamic_power'
.meas tran energy_per_cycle_idle_mux50[28]_in[4]_crossbar  param='dynamic_power_idle_mux50[28]_in[4]_crossbar*clock_period'
.meas tran dynamic_rise_idle_mux50[28]_in[4]_crossbar avg p(Vgvdd_mux_2level_size50[28]) from='start_rise_idle_mux50[28]_in[4]_crossbar' to='start_rise_idle_mux50[28]_in[4]_crossbar+switch_rise_idle_mux50[28]_in[4]_crossbar'
.meas tran dynamic_fall_idle_mux50[28]_in[4]_crossbar avg p(Vgvdd_mux_2level_size50[28]) from='start_fall_idle_mux50[28]_in[4]_crossbar' to='start_fall_idle_mux50[28]_in[4]_crossbar+switch_fall_idle_mux50[28]_in[4]_crossbar'
.meas tran sum_leakage_power_mux[0to28]
+          param='sum_leakage_power_mux[0to27]+leakage_idle_mux50[28]_in[4]_crossbar'
.meas tran sum_energy_per_cycle_mux[0to28]
+          param='sum_energy_per_cycle_mux[0to27]+energy_per_cycle_idle_mux50[28]_in[4]_crossbar'
Xload_inv[28]_no0 mux_2level_size50[28]->out mux_2level_size50[28]->out_out[0] gvdd_load 0 inv size=5
.meas tran sum_leakage_power_pb_mux[0to28]
+          param='sum_leakage_power_pb_mux[0to27]+leakage_idle_mux50[28]_in[4]_crossbar'
.meas tran sum_energy_per_cycle_pb_mux[0to28]
+          param='sum_energy_per_cycle_pb_mux[0to27]+energy_per_cycle_idle_mux50[28]_in[4]_crossbar'
Xmux_2level_size50[29] mux_2level_size50[29]->in[0] mux_2level_size50[29]->in[1] mux_2level_size50[29]->in[2] mux_2level_size50[29]->in[3] mux_2level_size50[29]->in[4] mux_2level_size50[29]->in[5] mux_2level_size50[29]->in[6] mux_2level_size50[29]->in[7] mux_2level_size50[29]->in[8] mux_2level_size50[29]->in[9] mux_2level_size50[29]->in[10] mux_2level_size50[29]->in[11] mux_2level_size50[29]->in[12] mux_2level_size50[29]->in[13] mux_2level_size50[29]->in[14] mux_2level_size50[29]->in[15] mux_2level_size50[29]->in[16] mux_2level_size50[29]->in[17] mux_2level_size50[29]->in[18] mux_2level_size50[29]->in[19] mux_2level_size50[29]->in[20] mux_2level_size50[29]->in[21] mux_2level_size50[29]->in[22] mux_2level_size50[29]->in[23] mux_2level_size50[29]->in[24] mux_2level_size50[29]->in[25] mux_2level_size50[29]->in[26] mux_2level_size50[29]->in[27] mux_2level_size50[29]->in[28] mux_2level_size50[29]->in[29] mux_2level_size50[29]->in[30] mux_2level_size50[29]->in[31] mux_2level_size50[29]->in[32] mux_2level_size50[29]->in[33] mux_2level_size50[29]->in[34] mux_2level_size50[29]->in[35] mux_2level_size50[29]->in[36] mux_2level_size50[29]->in[37] mux_2level_size50[29]->in[38] mux_2level_size50[29]->in[39] mux_2level_size50[29]->in[40] mux_2level_size50[29]->in[41] mux_2level_size50[29]->in[42] mux_2level_size50[29]->in[43] mux_2level_size50[29]->in[44] mux_2level_size50[29]->in[45] mux_2level_size50[29]->in[46] mux_2level_size50[29]->in[47] mux_2level_size50[29]->in[48] mux_2level_size50[29]->in[49] mux_2level_size50[29]->out sram[464]->outb sram[464]->out sram[465]->out sram[465]->outb sram[466]->out sram[466]->outb sram[467]->out sram[467]->outb sram[468]->out sram[468]->outb sram[469]->out sram[469]->outb sram[470]->out sram[470]->outb sram[471]->out sram[471]->outb sram[472]->outb sram[472]->out sram[473]->out sram[473]->outb sram[474]->out sram[474]->outb sram[475]->out sram[475]->outb sram[476]->out sram[476]->outb sram[477]->out sram[477]->outb sram[478]->out sram[478]->outb sram[479]->out sram[479]->outb gvdd_mux_2level_size50[29] 0 mux_2level_size50
***** SRAM bits for MUX[29], level=2, select_path_id=0. *****
*****1000000010000000*****
Xsram[464] sram->in sram[464]->out sram[464]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[464]->out) 0
.nodeset V(sram[464]->outb) vsp
Xsram[465] sram->in sram[465]->out sram[465]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[465]->out) 0
.nodeset V(sram[465]->outb) vsp
Xsram[466] sram->in sram[466]->out sram[466]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[466]->out) 0
.nodeset V(sram[466]->outb) vsp
Xsram[467] sram->in sram[467]->out sram[467]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[467]->out) 0
.nodeset V(sram[467]->outb) vsp
Xsram[468] sram->in sram[468]->out sram[468]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[468]->out) 0
.nodeset V(sram[468]->outb) vsp
Xsram[469] sram->in sram[469]->out sram[469]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[469]->out) 0
.nodeset V(sram[469]->outb) vsp
Xsram[470] sram->in sram[470]->out sram[470]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[470]->out) 0
.nodeset V(sram[470]->outb) vsp
Xsram[471] sram->in sram[471]->out sram[471]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[471]->out) 0
.nodeset V(sram[471]->outb) vsp
Xsram[472] sram->in sram[472]->out sram[472]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[472]->out) 0
.nodeset V(sram[472]->outb) vsp
Xsram[473] sram->in sram[473]->out sram[473]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[473]->out) 0
.nodeset V(sram[473]->outb) vsp
Xsram[474] sram->in sram[474]->out sram[474]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[474]->out) 0
.nodeset V(sram[474]->outb) vsp
Xsram[475] sram->in sram[475]->out sram[475]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[475]->out) 0
.nodeset V(sram[475]->outb) vsp
Xsram[476] sram->in sram[476]->out sram[476]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[476]->out) 0
.nodeset V(sram[476]->outb) vsp
Xsram[477] sram->in sram[477]->out sram[477]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[477]->out) 0
.nodeset V(sram[477]->outb) vsp
Xsram[478] sram->in sram[478]->out sram[478]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[478]->out) 0
.nodeset V(sram[478]->outb) vsp
Xsram[479] sram->in sram[479]->out sram[479]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[479]->out) 0
.nodeset V(sram[479]->outb) vsp
***** Signal mux_2level_size50[29]->in[0] density = 0, probability=0.*****
Vmux_2level_size50[29]->in[0] mux_2level_size50[29]->in[0] 0
+  0
***** Signal mux_2level_size50[29]->in[1] density = 0, probability=0.*****
Vmux_2level_size50[29]->in[1] mux_2level_size50[29]->in[1] 0
+  0
***** Signal mux_2level_size50[29]->in[2] density = 0, probability=0.*****
Vmux_2level_size50[29]->in[2] mux_2level_size50[29]->in[2] 0
+  0
***** Signal mux_2level_size50[29]->in[3] density = 0, probability=0.*****
Vmux_2level_size50[29]->in[3] mux_2level_size50[29]->in[3] 0
+  0
***** Signal mux_2level_size50[29]->in[4] density = 0, probability=0.*****
Vmux_2level_size50[29]->in[4] mux_2level_size50[29]->in[4] 0
+  0
***** Signal mux_2level_size50[29]->in[5] density = 0, probability=0.*****
Vmux_2level_size50[29]->in[5] mux_2level_size50[29]->in[5] 0
+  0
***** Signal mux_2level_size50[29]->in[6] density = 0, probability=0.*****
Vmux_2level_size50[29]->in[6] mux_2level_size50[29]->in[6] 0
+  0
***** Signal mux_2level_size50[29]->in[7] density = 0, probability=0.*****
Vmux_2level_size50[29]->in[7] mux_2level_size50[29]->in[7] 0
+  0
***** Signal mux_2level_size50[29]->in[8] density = 0, probability=0.*****
Vmux_2level_size50[29]->in[8] mux_2level_size50[29]->in[8] 0
+  0
***** Signal mux_2level_size50[29]->in[9] density = 0, probability=0.*****
Vmux_2level_size50[29]->in[9] mux_2level_size50[29]->in[9] 0
+  0
***** Signal mux_2level_size50[29]->in[10] density = 0, probability=0.*****
Vmux_2level_size50[29]->in[10] mux_2level_size50[29]->in[10] 0
+  0
***** Signal mux_2level_size50[29]->in[11] density = 0, probability=0.*****
Vmux_2level_size50[29]->in[11] mux_2level_size50[29]->in[11] 0
+  0
***** Signal mux_2level_size50[29]->in[12] density = 0, probability=0.*****
Vmux_2level_size50[29]->in[12] mux_2level_size50[29]->in[12] 0
+  0
***** Signal mux_2level_size50[29]->in[13] density = 0, probability=0.*****
Vmux_2level_size50[29]->in[13] mux_2level_size50[29]->in[13] 0
+  0
***** Signal mux_2level_size50[29]->in[14] density = 0, probability=0.*****
Vmux_2level_size50[29]->in[14] mux_2level_size50[29]->in[14] 0
+  0
***** Signal mux_2level_size50[29]->in[15] density = 0, probability=0.*****
Vmux_2level_size50[29]->in[15] mux_2level_size50[29]->in[15] 0
+  0
***** Signal mux_2level_size50[29]->in[16] density = 0, probability=0.*****
Vmux_2level_size50[29]->in[16] mux_2level_size50[29]->in[16] 0
+  0
***** Signal mux_2level_size50[29]->in[17] density = 0, probability=0.*****
Vmux_2level_size50[29]->in[17] mux_2level_size50[29]->in[17] 0
+  0
***** Signal mux_2level_size50[29]->in[18] density = 0, probability=0.*****
Vmux_2level_size50[29]->in[18] mux_2level_size50[29]->in[18] 0
+  0
***** Signal mux_2level_size50[29]->in[19] density = 0, probability=0.*****
Vmux_2level_size50[29]->in[19] mux_2level_size50[29]->in[19] 0
+  0
***** Signal mux_2level_size50[29]->in[20] density = 0, probability=0.*****
Vmux_2level_size50[29]->in[20] mux_2level_size50[29]->in[20] 0
+  0
***** Signal mux_2level_size50[29]->in[21] density = 0, probability=0.*****
Vmux_2level_size50[29]->in[21] mux_2level_size50[29]->in[21] 0
+  0
***** Signal mux_2level_size50[29]->in[22] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[29]->in[22] mux_2level_size50[29]->in[22] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[29]->in[23] density = 0, probability=0.*****
Vmux_2level_size50[29]->in[23] mux_2level_size50[29]->in[23] 0
+  0
***** Signal mux_2level_size50[29]->in[24] density = 0, probability=0.*****
Vmux_2level_size50[29]->in[24] mux_2level_size50[29]->in[24] 0
+  0
***** Signal mux_2level_size50[29]->in[25] density = 0, probability=0.*****
Vmux_2level_size50[29]->in[25] mux_2level_size50[29]->in[25] 0
+  0
***** Signal mux_2level_size50[29]->in[26] density = 0, probability=0.*****
Vmux_2level_size50[29]->in[26] mux_2level_size50[29]->in[26] 0
+  0
***** Signal mux_2level_size50[29]->in[27] density = 0, probability=0.*****
Vmux_2level_size50[29]->in[27] mux_2level_size50[29]->in[27] 0
+  0
***** Signal mux_2level_size50[29]->in[28] density = 0, probability=0.*****
Vmux_2level_size50[29]->in[28] mux_2level_size50[29]->in[28] 0
+  0
***** Signal mux_2level_size50[29]->in[29] density = 0, probability=0.*****
Vmux_2level_size50[29]->in[29] mux_2level_size50[29]->in[29] 0
+  0
***** Signal mux_2level_size50[29]->in[30] density = 0, probability=0.*****
Vmux_2level_size50[29]->in[30] mux_2level_size50[29]->in[30] 0
+  0
***** Signal mux_2level_size50[29]->in[31] density = 0, probability=0.*****
Vmux_2level_size50[29]->in[31] mux_2level_size50[29]->in[31] 0
+  0
***** Signal mux_2level_size50[29]->in[32] density = 0, probability=0.*****
Vmux_2level_size50[29]->in[32] mux_2level_size50[29]->in[32] 0
+  0
***** Signal mux_2level_size50[29]->in[33] density = 0, probability=0.*****
Vmux_2level_size50[29]->in[33] mux_2level_size50[29]->in[33] 0
+  0
***** Signal mux_2level_size50[29]->in[34] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[29]->in[34] mux_2level_size50[29]->in[34] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[29]->in[35] density = 0, probability=0.*****
Vmux_2level_size50[29]->in[35] mux_2level_size50[29]->in[35] 0
+  0
***** Signal mux_2level_size50[29]->in[36] density = 0, probability=0.*****
Vmux_2level_size50[29]->in[36] mux_2level_size50[29]->in[36] 0
+  0
***** Signal mux_2level_size50[29]->in[37] density = 0, probability=0.*****
Vmux_2level_size50[29]->in[37] mux_2level_size50[29]->in[37] 0
+  0
***** Signal mux_2level_size50[29]->in[38] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[29]->in[38] mux_2level_size50[29]->in[38] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[29]->in[39] density = 0, probability=0.*****
Vmux_2level_size50[29]->in[39] mux_2level_size50[29]->in[39] 0
+  0
***** Signal mux_2level_size50[29]->in[40] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[29]->in[40] mux_2level_size50[29]->in[40] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[29]->in[41] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[29]->in[41] mux_2level_size50[29]->in[41] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[29]->in[42] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[29]->in[42] mux_2level_size50[29]->in[42] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[29]->in[43] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[29]->in[43] mux_2level_size50[29]->in[43] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[29]->in[44] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[29]->in[44] mux_2level_size50[29]->in[44] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[29]->in[45] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[29]->in[45] mux_2level_size50[29]->in[45] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[29]->in[46] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[29]->in[46] mux_2level_size50[29]->in[46] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[29]->in[47] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[29]->in[47] mux_2level_size50[29]->in[47] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[29]->in[48] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[29]->in[48] mux_2level_size50[29]->in[48] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[29]->in[49] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[29]->in[49] mux_2level_size50[29]->in[49] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
Vgvdd_mux_2level_size50[29] gvdd_mux_2level_size50[29] 0 vsp
***** Measurements *****
***** Rise delay *****
.meas tran delay_rise_idle_mux50[29]_in[5]_crossbar trig v(mux_2level_size50[29]->in[0]) val='input_thres_pct_rise*vsp' rise=1 td='clock_period'
+          targ v(mux_2level_size50[29]->out) val='output_thres_pct_rise*vsp' rise=1 td='clock_period'
***** Fall delay *****
.meas tran delay_fall_idle_mux50[29]_in[5]_crossbar trig v(mux_2level_size50[29]->in[0]) val='input_thres_pct_fall*vsp' fall=1 td='clock_period'
+          targ v(mux_2level_size50[29]->out) val='output_thres_pct_fall*vsp' fall=1 td='clock_period'
***** Rise timing period *****
.meas start_rise_idle_mux50[29]_in[5]_crossbar when v(mux_2level_size50[29]->in[0])='slew_lower_thres_pct_rise*vsp' rise=1 td='clock_period'
.meas tran switch_rise_idle_mux50[29]_in[5]_crossbar trig v(mux_2level_size50[29]->in[0]) val='slew_lower_thres_pct_rise*vsp' rise=1 td='clock_period'
+          targ v(mux_2level_size50[29]->out) val='slew_upper_thres_pct_rise*vsp' rise=1 td='clock_period'
***** Fall timing period *****
.meas start_fall_idle_mux50[29]_in[5]_crossbar when v(mux_2level_size50[29]->in[0])='slew_lower_thres_pct_fall*vsp' fall=1 td='clock_period'
.meas tran switch_fall_idle_mux50[29]_in[5]_crossbar trig v(mux_2level_size50[29]->in[0]) val='slew_lower_thres_pct_fall*vsp' fall=1 td='clock_period'
+          targ v(mux_2level_size50[29]->out) val='slew_upper_thres_pct_fall*vsp' fall=1 td='clock_period'
***** Leakage Power Measurement *****
.meas tran mux_2level_size50[29]_leakage_power avg p(Vgvdd_mux_2level_size50[29]) from=0 to='clock_period'
.meas tran leakage_idle_mux50[29]_in[5]_crossbar param='mux_2level_size50[29]_leakage_power'
***** Dynamic Power Measurement *****
.meas tran mux_2level_size50[29]_dynamic_power avg p(Vgvdd_mux_2level_size50[29]) from='clock_period' to='6*clock_period'
.meas tran mux_2level_size50[29]_energy_per_cycle param='mux_2level_size50[29]_dynamic_power*clock_period'
.meas tran dynamic_power_idle_mux50[29]_in[5]_crossbar  param='mux_2level_size50[29]_dynamic_power'
.meas tran energy_per_cycle_idle_mux50[29]_in[5]_crossbar  param='dynamic_power_idle_mux50[29]_in[5]_crossbar*clock_period'
.meas tran dynamic_rise_idle_mux50[29]_in[5]_crossbar avg p(Vgvdd_mux_2level_size50[29]) from='start_rise_idle_mux50[29]_in[5]_crossbar' to='start_rise_idle_mux50[29]_in[5]_crossbar+switch_rise_idle_mux50[29]_in[5]_crossbar'
.meas tran dynamic_fall_idle_mux50[29]_in[5]_crossbar avg p(Vgvdd_mux_2level_size50[29]) from='start_fall_idle_mux50[29]_in[5]_crossbar' to='start_fall_idle_mux50[29]_in[5]_crossbar+switch_fall_idle_mux50[29]_in[5]_crossbar'
.meas tran sum_leakage_power_mux[0to29]
+          param='sum_leakage_power_mux[0to28]+leakage_idle_mux50[29]_in[5]_crossbar'
.meas tran sum_energy_per_cycle_mux[0to29]
+          param='sum_energy_per_cycle_mux[0to28]+energy_per_cycle_idle_mux50[29]_in[5]_crossbar'
Xload_inv[29]_no0 mux_2level_size50[29]->out mux_2level_size50[29]->out_out[0] gvdd_load 0 inv size=5
.meas tran sum_leakage_power_pb_mux[0to29]
+          param='sum_leakage_power_pb_mux[0to28]+leakage_idle_mux50[29]_in[5]_crossbar'
.meas tran sum_energy_per_cycle_pb_mux[0to29]
+          param='sum_energy_per_cycle_pb_mux[0to28]+energy_per_cycle_idle_mux50[29]_in[5]_crossbar'
Xmux_2level_size50[30] mux_2level_size50[30]->in[0] mux_2level_size50[30]->in[1] mux_2level_size50[30]->in[2] mux_2level_size50[30]->in[3] mux_2level_size50[30]->in[4] mux_2level_size50[30]->in[5] mux_2level_size50[30]->in[6] mux_2level_size50[30]->in[7] mux_2level_size50[30]->in[8] mux_2level_size50[30]->in[9] mux_2level_size50[30]->in[10] mux_2level_size50[30]->in[11] mux_2level_size50[30]->in[12] mux_2level_size50[30]->in[13] mux_2level_size50[30]->in[14] mux_2level_size50[30]->in[15] mux_2level_size50[30]->in[16] mux_2level_size50[30]->in[17] mux_2level_size50[30]->in[18] mux_2level_size50[30]->in[19] mux_2level_size50[30]->in[20] mux_2level_size50[30]->in[21] mux_2level_size50[30]->in[22] mux_2level_size50[30]->in[23] mux_2level_size50[30]->in[24] mux_2level_size50[30]->in[25] mux_2level_size50[30]->in[26] mux_2level_size50[30]->in[27] mux_2level_size50[30]->in[28] mux_2level_size50[30]->in[29] mux_2level_size50[30]->in[30] mux_2level_size50[30]->in[31] mux_2level_size50[30]->in[32] mux_2level_size50[30]->in[33] mux_2level_size50[30]->in[34] mux_2level_size50[30]->in[35] mux_2level_size50[30]->in[36] mux_2level_size50[30]->in[37] mux_2level_size50[30]->in[38] mux_2level_size50[30]->in[39] mux_2level_size50[30]->in[40] mux_2level_size50[30]->in[41] mux_2level_size50[30]->in[42] mux_2level_size50[30]->in[43] mux_2level_size50[30]->in[44] mux_2level_size50[30]->in[45] mux_2level_size50[30]->in[46] mux_2level_size50[30]->in[47] mux_2level_size50[30]->in[48] mux_2level_size50[30]->in[49] mux_2level_size50[30]->out sram[480]->outb sram[480]->out sram[481]->out sram[481]->outb sram[482]->out sram[482]->outb sram[483]->out sram[483]->outb sram[484]->out sram[484]->outb sram[485]->out sram[485]->outb sram[486]->out sram[486]->outb sram[487]->out sram[487]->outb sram[488]->outb sram[488]->out sram[489]->out sram[489]->outb sram[490]->out sram[490]->outb sram[491]->out sram[491]->outb sram[492]->out sram[492]->outb sram[493]->out sram[493]->outb sram[494]->out sram[494]->outb sram[495]->out sram[495]->outb gvdd_mux_2level_size50[30] 0 mux_2level_size50
***** SRAM bits for MUX[30], level=2, select_path_id=0. *****
*****1000000010000000*****
Xsram[480] sram->in sram[480]->out sram[480]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[480]->out) 0
.nodeset V(sram[480]->outb) vsp
Xsram[481] sram->in sram[481]->out sram[481]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[481]->out) 0
.nodeset V(sram[481]->outb) vsp
Xsram[482] sram->in sram[482]->out sram[482]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[482]->out) 0
.nodeset V(sram[482]->outb) vsp
Xsram[483] sram->in sram[483]->out sram[483]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[483]->out) 0
.nodeset V(sram[483]->outb) vsp
Xsram[484] sram->in sram[484]->out sram[484]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[484]->out) 0
.nodeset V(sram[484]->outb) vsp
Xsram[485] sram->in sram[485]->out sram[485]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[485]->out) 0
.nodeset V(sram[485]->outb) vsp
Xsram[486] sram->in sram[486]->out sram[486]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[486]->out) 0
.nodeset V(sram[486]->outb) vsp
Xsram[487] sram->in sram[487]->out sram[487]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[487]->out) 0
.nodeset V(sram[487]->outb) vsp
Xsram[488] sram->in sram[488]->out sram[488]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[488]->out) 0
.nodeset V(sram[488]->outb) vsp
Xsram[489] sram->in sram[489]->out sram[489]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[489]->out) 0
.nodeset V(sram[489]->outb) vsp
Xsram[490] sram->in sram[490]->out sram[490]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[490]->out) 0
.nodeset V(sram[490]->outb) vsp
Xsram[491] sram->in sram[491]->out sram[491]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[491]->out) 0
.nodeset V(sram[491]->outb) vsp
Xsram[492] sram->in sram[492]->out sram[492]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[492]->out) 0
.nodeset V(sram[492]->outb) vsp
Xsram[493] sram->in sram[493]->out sram[493]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[493]->out) 0
.nodeset V(sram[493]->outb) vsp
Xsram[494] sram->in sram[494]->out sram[494]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[494]->out) 0
.nodeset V(sram[494]->outb) vsp
Xsram[495] sram->in sram[495]->out sram[495]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[495]->out) 0
.nodeset V(sram[495]->outb) vsp
***** Signal mux_2level_size50[30]->in[0] density = 0, probability=0.*****
Vmux_2level_size50[30]->in[0] mux_2level_size50[30]->in[0] 0
+  0
***** Signal mux_2level_size50[30]->in[1] density = 0, probability=0.*****
Vmux_2level_size50[30]->in[1] mux_2level_size50[30]->in[1] 0
+  0
***** Signal mux_2level_size50[30]->in[2] density = 0, probability=0.*****
Vmux_2level_size50[30]->in[2] mux_2level_size50[30]->in[2] 0
+  0
***** Signal mux_2level_size50[30]->in[3] density = 0, probability=0.*****
Vmux_2level_size50[30]->in[3] mux_2level_size50[30]->in[3] 0
+  0
***** Signal mux_2level_size50[30]->in[4] density = 0, probability=0.*****
Vmux_2level_size50[30]->in[4] mux_2level_size50[30]->in[4] 0
+  0
***** Signal mux_2level_size50[30]->in[5] density = 0, probability=0.*****
Vmux_2level_size50[30]->in[5] mux_2level_size50[30]->in[5] 0
+  0
***** Signal mux_2level_size50[30]->in[6] density = 0, probability=0.*****
Vmux_2level_size50[30]->in[6] mux_2level_size50[30]->in[6] 0
+  0
***** Signal mux_2level_size50[30]->in[7] density = 0, probability=0.*****
Vmux_2level_size50[30]->in[7] mux_2level_size50[30]->in[7] 0
+  0
***** Signal mux_2level_size50[30]->in[8] density = 0, probability=0.*****
Vmux_2level_size50[30]->in[8] mux_2level_size50[30]->in[8] 0
+  0
***** Signal mux_2level_size50[30]->in[9] density = 0, probability=0.*****
Vmux_2level_size50[30]->in[9] mux_2level_size50[30]->in[9] 0
+  0
***** Signal mux_2level_size50[30]->in[10] density = 0, probability=0.*****
Vmux_2level_size50[30]->in[10] mux_2level_size50[30]->in[10] 0
+  0
***** Signal mux_2level_size50[30]->in[11] density = 0, probability=0.*****
Vmux_2level_size50[30]->in[11] mux_2level_size50[30]->in[11] 0
+  0
***** Signal mux_2level_size50[30]->in[12] density = 0, probability=0.*****
Vmux_2level_size50[30]->in[12] mux_2level_size50[30]->in[12] 0
+  0
***** Signal mux_2level_size50[30]->in[13] density = 0, probability=0.*****
Vmux_2level_size50[30]->in[13] mux_2level_size50[30]->in[13] 0
+  0
***** Signal mux_2level_size50[30]->in[14] density = 0, probability=0.*****
Vmux_2level_size50[30]->in[14] mux_2level_size50[30]->in[14] 0
+  0
***** Signal mux_2level_size50[30]->in[15] density = 0, probability=0.*****
Vmux_2level_size50[30]->in[15] mux_2level_size50[30]->in[15] 0
+  0
***** Signal mux_2level_size50[30]->in[16] density = 0, probability=0.*****
Vmux_2level_size50[30]->in[16] mux_2level_size50[30]->in[16] 0
+  0
***** Signal mux_2level_size50[30]->in[17] density = 0, probability=0.*****
Vmux_2level_size50[30]->in[17] mux_2level_size50[30]->in[17] 0
+  0
***** Signal mux_2level_size50[30]->in[18] density = 0, probability=0.*****
Vmux_2level_size50[30]->in[18] mux_2level_size50[30]->in[18] 0
+  0
***** Signal mux_2level_size50[30]->in[19] density = 0, probability=0.*****
Vmux_2level_size50[30]->in[19] mux_2level_size50[30]->in[19] 0
+  0
***** Signal mux_2level_size50[30]->in[20] density = 0, probability=0.*****
Vmux_2level_size50[30]->in[20] mux_2level_size50[30]->in[20] 0
+  0
***** Signal mux_2level_size50[30]->in[21] density = 0, probability=0.*****
Vmux_2level_size50[30]->in[21] mux_2level_size50[30]->in[21] 0
+  0
***** Signal mux_2level_size50[30]->in[22] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[30]->in[22] mux_2level_size50[30]->in[22] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[30]->in[23] density = 0, probability=0.*****
Vmux_2level_size50[30]->in[23] mux_2level_size50[30]->in[23] 0
+  0
***** Signal mux_2level_size50[30]->in[24] density = 0, probability=0.*****
Vmux_2level_size50[30]->in[24] mux_2level_size50[30]->in[24] 0
+  0
***** Signal mux_2level_size50[30]->in[25] density = 0, probability=0.*****
Vmux_2level_size50[30]->in[25] mux_2level_size50[30]->in[25] 0
+  0
***** Signal mux_2level_size50[30]->in[26] density = 0, probability=0.*****
Vmux_2level_size50[30]->in[26] mux_2level_size50[30]->in[26] 0
+  0
***** Signal mux_2level_size50[30]->in[27] density = 0, probability=0.*****
Vmux_2level_size50[30]->in[27] mux_2level_size50[30]->in[27] 0
+  0
***** Signal mux_2level_size50[30]->in[28] density = 0, probability=0.*****
Vmux_2level_size50[30]->in[28] mux_2level_size50[30]->in[28] 0
+  0
***** Signal mux_2level_size50[30]->in[29] density = 0, probability=0.*****
Vmux_2level_size50[30]->in[29] mux_2level_size50[30]->in[29] 0
+  0
***** Signal mux_2level_size50[30]->in[30] density = 0, probability=0.*****
Vmux_2level_size50[30]->in[30] mux_2level_size50[30]->in[30] 0
+  0
***** Signal mux_2level_size50[30]->in[31] density = 0, probability=0.*****
Vmux_2level_size50[30]->in[31] mux_2level_size50[30]->in[31] 0
+  0
***** Signal mux_2level_size50[30]->in[32] density = 0, probability=0.*****
Vmux_2level_size50[30]->in[32] mux_2level_size50[30]->in[32] 0
+  0
***** Signal mux_2level_size50[30]->in[33] density = 0, probability=0.*****
Vmux_2level_size50[30]->in[33] mux_2level_size50[30]->in[33] 0
+  0
***** Signal mux_2level_size50[30]->in[34] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[30]->in[34] mux_2level_size50[30]->in[34] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[30]->in[35] density = 0, probability=0.*****
Vmux_2level_size50[30]->in[35] mux_2level_size50[30]->in[35] 0
+  0
***** Signal mux_2level_size50[30]->in[36] density = 0, probability=0.*****
Vmux_2level_size50[30]->in[36] mux_2level_size50[30]->in[36] 0
+  0
***** Signal mux_2level_size50[30]->in[37] density = 0, probability=0.*****
Vmux_2level_size50[30]->in[37] mux_2level_size50[30]->in[37] 0
+  0
***** Signal mux_2level_size50[30]->in[38] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[30]->in[38] mux_2level_size50[30]->in[38] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[30]->in[39] density = 0, probability=0.*****
Vmux_2level_size50[30]->in[39] mux_2level_size50[30]->in[39] 0
+  0
***** Signal mux_2level_size50[30]->in[40] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[30]->in[40] mux_2level_size50[30]->in[40] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[30]->in[41] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[30]->in[41] mux_2level_size50[30]->in[41] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[30]->in[42] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[30]->in[42] mux_2level_size50[30]->in[42] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[30]->in[43] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[30]->in[43] mux_2level_size50[30]->in[43] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[30]->in[44] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[30]->in[44] mux_2level_size50[30]->in[44] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[30]->in[45] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[30]->in[45] mux_2level_size50[30]->in[45] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[30]->in[46] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[30]->in[46] mux_2level_size50[30]->in[46] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[30]->in[47] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[30]->in[47] mux_2level_size50[30]->in[47] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[30]->in[48] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[30]->in[48] mux_2level_size50[30]->in[48] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[30]->in[49] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[30]->in[49] mux_2level_size50[30]->in[49] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
Vgvdd_mux_2level_size50[30] gvdd_mux_2level_size50[30] 0 vsp
***** Measurements *****
***** Rise delay *****
.meas tran delay_rise_idle_mux50[30]_in[0]_crossbar trig v(mux_2level_size50[30]->in[0]) val='input_thres_pct_rise*vsp' rise=1 td='clock_period'
+          targ v(mux_2level_size50[30]->out) val='output_thres_pct_rise*vsp' rise=1 td='clock_period'
***** Fall delay *****
.meas tran delay_fall_idle_mux50[30]_in[0]_crossbar trig v(mux_2level_size50[30]->in[0]) val='input_thres_pct_fall*vsp' fall=1 td='clock_period'
+          targ v(mux_2level_size50[30]->out) val='output_thres_pct_fall*vsp' fall=1 td='clock_period'
***** Rise timing period *****
.meas start_rise_idle_mux50[30]_in[0]_crossbar when v(mux_2level_size50[30]->in[0])='slew_lower_thres_pct_rise*vsp' rise=1 td='clock_period'
.meas tran switch_rise_idle_mux50[30]_in[0]_crossbar trig v(mux_2level_size50[30]->in[0]) val='slew_lower_thres_pct_rise*vsp' rise=1 td='clock_period'
+          targ v(mux_2level_size50[30]->out) val='slew_upper_thres_pct_rise*vsp' rise=1 td='clock_period'
***** Fall timing period *****
.meas start_fall_idle_mux50[30]_in[0]_crossbar when v(mux_2level_size50[30]->in[0])='slew_lower_thres_pct_fall*vsp' fall=1 td='clock_period'
.meas tran switch_fall_idle_mux50[30]_in[0]_crossbar trig v(mux_2level_size50[30]->in[0]) val='slew_lower_thres_pct_fall*vsp' fall=1 td='clock_period'
+          targ v(mux_2level_size50[30]->out) val='slew_upper_thres_pct_fall*vsp' fall=1 td='clock_period'
***** Leakage Power Measurement *****
.meas tran mux_2level_size50[30]_leakage_power avg p(Vgvdd_mux_2level_size50[30]) from=0 to='clock_period'
.meas tran leakage_idle_mux50[30]_in[0]_crossbar param='mux_2level_size50[30]_leakage_power'
***** Dynamic Power Measurement *****
.meas tran mux_2level_size50[30]_dynamic_power avg p(Vgvdd_mux_2level_size50[30]) from='clock_period' to='6*clock_period'
.meas tran mux_2level_size50[30]_energy_per_cycle param='mux_2level_size50[30]_dynamic_power*clock_period'
.meas tran dynamic_power_idle_mux50[30]_in[0]_crossbar  param='mux_2level_size50[30]_dynamic_power'
.meas tran energy_per_cycle_idle_mux50[30]_in[0]_crossbar  param='dynamic_power_idle_mux50[30]_in[0]_crossbar*clock_period'
.meas tran dynamic_rise_idle_mux50[30]_in[0]_crossbar avg p(Vgvdd_mux_2level_size50[30]) from='start_rise_idle_mux50[30]_in[0]_crossbar' to='start_rise_idle_mux50[30]_in[0]_crossbar+switch_rise_idle_mux50[30]_in[0]_crossbar'
.meas tran dynamic_fall_idle_mux50[30]_in[0]_crossbar avg p(Vgvdd_mux_2level_size50[30]) from='start_fall_idle_mux50[30]_in[0]_crossbar' to='start_fall_idle_mux50[30]_in[0]_crossbar+switch_fall_idle_mux50[30]_in[0]_crossbar'
.meas tran sum_leakage_power_mux[0to30]
+          param='sum_leakage_power_mux[0to29]+leakage_idle_mux50[30]_in[0]_crossbar'
.meas tran sum_energy_per_cycle_mux[0to30]
+          param='sum_energy_per_cycle_mux[0to29]+energy_per_cycle_idle_mux50[30]_in[0]_crossbar'
Xload_inv[30]_no0 mux_2level_size50[30]->out mux_2level_size50[30]->out_out[0] gvdd_load 0 inv size=5
.meas tran sum_leakage_power_pb_mux[0to30]
+          param='sum_leakage_power_pb_mux[0to29]+leakage_idle_mux50[30]_in[0]_crossbar'
.meas tran sum_energy_per_cycle_pb_mux[0to30]
+          param='sum_energy_per_cycle_pb_mux[0to29]+energy_per_cycle_idle_mux50[30]_in[0]_crossbar'
Xmux_2level_size50[31] mux_2level_size50[31]->in[0] mux_2level_size50[31]->in[1] mux_2level_size50[31]->in[2] mux_2level_size50[31]->in[3] mux_2level_size50[31]->in[4] mux_2level_size50[31]->in[5] mux_2level_size50[31]->in[6] mux_2level_size50[31]->in[7] mux_2level_size50[31]->in[8] mux_2level_size50[31]->in[9] mux_2level_size50[31]->in[10] mux_2level_size50[31]->in[11] mux_2level_size50[31]->in[12] mux_2level_size50[31]->in[13] mux_2level_size50[31]->in[14] mux_2level_size50[31]->in[15] mux_2level_size50[31]->in[16] mux_2level_size50[31]->in[17] mux_2level_size50[31]->in[18] mux_2level_size50[31]->in[19] mux_2level_size50[31]->in[20] mux_2level_size50[31]->in[21] mux_2level_size50[31]->in[22] mux_2level_size50[31]->in[23] mux_2level_size50[31]->in[24] mux_2level_size50[31]->in[25] mux_2level_size50[31]->in[26] mux_2level_size50[31]->in[27] mux_2level_size50[31]->in[28] mux_2level_size50[31]->in[29] mux_2level_size50[31]->in[30] mux_2level_size50[31]->in[31] mux_2level_size50[31]->in[32] mux_2level_size50[31]->in[33] mux_2level_size50[31]->in[34] mux_2level_size50[31]->in[35] mux_2level_size50[31]->in[36] mux_2level_size50[31]->in[37] mux_2level_size50[31]->in[38] mux_2level_size50[31]->in[39] mux_2level_size50[31]->in[40] mux_2level_size50[31]->in[41] mux_2level_size50[31]->in[42] mux_2level_size50[31]->in[43] mux_2level_size50[31]->in[44] mux_2level_size50[31]->in[45] mux_2level_size50[31]->in[46] mux_2level_size50[31]->in[47] mux_2level_size50[31]->in[48] mux_2level_size50[31]->in[49] mux_2level_size50[31]->out sram[496]->outb sram[496]->out sram[497]->out sram[497]->outb sram[498]->out sram[498]->outb sram[499]->out sram[499]->outb sram[500]->out sram[500]->outb sram[501]->out sram[501]->outb sram[502]->out sram[502]->outb sram[503]->out sram[503]->outb sram[504]->outb sram[504]->out sram[505]->out sram[505]->outb sram[506]->out sram[506]->outb sram[507]->out sram[507]->outb sram[508]->out sram[508]->outb sram[509]->out sram[509]->outb sram[510]->out sram[510]->outb sram[511]->out sram[511]->outb gvdd_mux_2level_size50[31] 0 mux_2level_size50
***** SRAM bits for MUX[31], level=2, select_path_id=0. *****
*****1000000010000000*****
Xsram[496] sram->in sram[496]->out sram[496]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[496]->out) 0
.nodeset V(sram[496]->outb) vsp
Xsram[497] sram->in sram[497]->out sram[497]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[497]->out) 0
.nodeset V(sram[497]->outb) vsp
Xsram[498] sram->in sram[498]->out sram[498]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[498]->out) 0
.nodeset V(sram[498]->outb) vsp
Xsram[499] sram->in sram[499]->out sram[499]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[499]->out) 0
.nodeset V(sram[499]->outb) vsp
Xsram[500] sram->in sram[500]->out sram[500]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[500]->out) 0
.nodeset V(sram[500]->outb) vsp
Xsram[501] sram->in sram[501]->out sram[501]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[501]->out) 0
.nodeset V(sram[501]->outb) vsp
Xsram[502] sram->in sram[502]->out sram[502]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[502]->out) 0
.nodeset V(sram[502]->outb) vsp
Xsram[503] sram->in sram[503]->out sram[503]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[503]->out) 0
.nodeset V(sram[503]->outb) vsp
Xsram[504] sram->in sram[504]->out sram[504]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[504]->out) 0
.nodeset V(sram[504]->outb) vsp
Xsram[505] sram->in sram[505]->out sram[505]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[505]->out) 0
.nodeset V(sram[505]->outb) vsp
Xsram[506] sram->in sram[506]->out sram[506]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[506]->out) 0
.nodeset V(sram[506]->outb) vsp
Xsram[507] sram->in sram[507]->out sram[507]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[507]->out) 0
.nodeset V(sram[507]->outb) vsp
Xsram[508] sram->in sram[508]->out sram[508]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[508]->out) 0
.nodeset V(sram[508]->outb) vsp
Xsram[509] sram->in sram[509]->out sram[509]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[509]->out) 0
.nodeset V(sram[509]->outb) vsp
Xsram[510] sram->in sram[510]->out sram[510]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[510]->out) 0
.nodeset V(sram[510]->outb) vsp
Xsram[511] sram->in sram[511]->out sram[511]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[511]->out) 0
.nodeset V(sram[511]->outb) vsp
***** Signal mux_2level_size50[31]->in[0] density = 0, probability=0.*****
Vmux_2level_size50[31]->in[0] mux_2level_size50[31]->in[0] 0
+  0
***** Signal mux_2level_size50[31]->in[1] density = 0, probability=0.*****
Vmux_2level_size50[31]->in[1] mux_2level_size50[31]->in[1] 0
+  0
***** Signal mux_2level_size50[31]->in[2] density = 0, probability=0.*****
Vmux_2level_size50[31]->in[2] mux_2level_size50[31]->in[2] 0
+  0
***** Signal mux_2level_size50[31]->in[3] density = 0, probability=0.*****
Vmux_2level_size50[31]->in[3] mux_2level_size50[31]->in[3] 0
+  0
***** Signal mux_2level_size50[31]->in[4] density = 0, probability=0.*****
Vmux_2level_size50[31]->in[4] mux_2level_size50[31]->in[4] 0
+  0
***** Signal mux_2level_size50[31]->in[5] density = 0, probability=0.*****
Vmux_2level_size50[31]->in[5] mux_2level_size50[31]->in[5] 0
+  0
***** Signal mux_2level_size50[31]->in[6] density = 0, probability=0.*****
Vmux_2level_size50[31]->in[6] mux_2level_size50[31]->in[6] 0
+  0
***** Signal mux_2level_size50[31]->in[7] density = 0, probability=0.*****
Vmux_2level_size50[31]->in[7] mux_2level_size50[31]->in[7] 0
+  0
***** Signal mux_2level_size50[31]->in[8] density = 0, probability=0.*****
Vmux_2level_size50[31]->in[8] mux_2level_size50[31]->in[8] 0
+  0
***** Signal mux_2level_size50[31]->in[9] density = 0, probability=0.*****
Vmux_2level_size50[31]->in[9] mux_2level_size50[31]->in[9] 0
+  0
***** Signal mux_2level_size50[31]->in[10] density = 0, probability=0.*****
Vmux_2level_size50[31]->in[10] mux_2level_size50[31]->in[10] 0
+  0
***** Signal mux_2level_size50[31]->in[11] density = 0, probability=0.*****
Vmux_2level_size50[31]->in[11] mux_2level_size50[31]->in[11] 0
+  0
***** Signal mux_2level_size50[31]->in[12] density = 0, probability=0.*****
Vmux_2level_size50[31]->in[12] mux_2level_size50[31]->in[12] 0
+  0
***** Signal mux_2level_size50[31]->in[13] density = 0, probability=0.*****
Vmux_2level_size50[31]->in[13] mux_2level_size50[31]->in[13] 0
+  0
***** Signal mux_2level_size50[31]->in[14] density = 0, probability=0.*****
Vmux_2level_size50[31]->in[14] mux_2level_size50[31]->in[14] 0
+  0
***** Signal mux_2level_size50[31]->in[15] density = 0, probability=0.*****
Vmux_2level_size50[31]->in[15] mux_2level_size50[31]->in[15] 0
+  0
***** Signal mux_2level_size50[31]->in[16] density = 0, probability=0.*****
Vmux_2level_size50[31]->in[16] mux_2level_size50[31]->in[16] 0
+  0
***** Signal mux_2level_size50[31]->in[17] density = 0, probability=0.*****
Vmux_2level_size50[31]->in[17] mux_2level_size50[31]->in[17] 0
+  0
***** Signal mux_2level_size50[31]->in[18] density = 0, probability=0.*****
Vmux_2level_size50[31]->in[18] mux_2level_size50[31]->in[18] 0
+  0
***** Signal mux_2level_size50[31]->in[19] density = 0, probability=0.*****
Vmux_2level_size50[31]->in[19] mux_2level_size50[31]->in[19] 0
+  0
***** Signal mux_2level_size50[31]->in[20] density = 0, probability=0.*****
Vmux_2level_size50[31]->in[20] mux_2level_size50[31]->in[20] 0
+  0
***** Signal mux_2level_size50[31]->in[21] density = 0, probability=0.*****
Vmux_2level_size50[31]->in[21] mux_2level_size50[31]->in[21] 0
+  0
***** Signal mux_2level_size50[31]->in[22] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[31]->in[22] mux_2level_size50[31]->in[22] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[31]->in[23] density = 0, probability=0.*****
Vmux_2level_size50[31]->in[23] mux_2level_size50[31]->in[23] 0
+  0
***** Signal mux_2level_size50[31]->in[24] density = 0, probability=0.*****
Vmux_2level_size50[31]->in[24] mux_2level_size50[31]->in[24] 0
+  0
***** Signal mux_2level_size50[31]->in[25] density = 0, probability=0.*****
Vmux_2level_size50[31]->in[25] mux_2level_size50[31]->in[25] 0
+  0
***** Signal mux_2level_size50[31]->in[26] density = 0, probability=0.*****
Vmux_2level_size50[31]->in[26] mux_2level_size50[31]->in[26] 0
+  0
***** Signal mux_2level_size50[31]->in[27] density = 0, probability=0.*****
Vmux_2level_size50[31]->in[27] mux_2level_size50[31]->in[27] 0
+  0
***** Signal mux_2level_size50[31]->in[28] density = 0, probability=0.*****
Vmux_2level_size50[31]->in[28] mux_2level_size50[31]->in[28] 0
+  0
***** Signal mux_2level_size50[31]->in[29] density = 0, probability=0.*****
Vmux_2level_size50[31]->in[29] mux_2level_size50[31]->in[29] 0
+  0
***** Signal mux_2level_size50[31]->in[30] density = 0, probability=0.*****
Vmux_2level_size50[31]->in[30] mux_2level_size50[31]->in[30] 0
+  0
***** Signal mux_2level_size50[31]->in[31] density = 0, probability=0.*****
Vmux_2level_size50[31]->in[31] mux_2level_size50[31]->in[31] 0
+  0
***** Signal mux_2level_size50[31]->in[32] density = 0, probability=0.*****
Vmux_2level_size50[31]->in[32] mux_2level_size50[31]->in[32] 0
+  0
***** Signal mux_2level_size50[31]->in[33] density = 0, probability=0.*****
Vmux_2level_size50[31]->in[33] mux_2level_size50[31]->in[33] 0
+  0
***** Signal mux_2level_size50[31]->in[34] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[31]->in[34] mux_2level_size50[31]->in[34] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[31]->in[35] density = 0, probability=0.*****
Vmux_2level_size50[31]->in[35] mux_2level_size50[31]->in[35] 0
+  0
***** Signal mux_2level_size50[31]->in[36] density = 0, probability=0.*****
Vmux_2level_size50[31]->in[36] mux_2level_size50[31]->in[36] 0
+  0
***** Signal mux_2level_size50[31]->in[37] density = 0, probability=0.*****
Vmux_2level_size50[31]->in[37] mux_2level_size50[31]->in[37] 0
+  0
***** Signal mux_2level_size50[31]->in[38] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[31]->in[38] mux_2level_size50[31]->in[38] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[31]->in[39] density = 0, probability=0.*****
Vmux_2level_size50[31]->in[39] mux_2level_size50[31]->in[39] 0
+  0
***** Signal mux_2level_size50[31]->in[40] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[31]->in[40] mux_2level_size50[31]->in[40] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[31]->in[41] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[31]->in[41] mux_2level_size50[31]->in[41] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[31]->in[42] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[31]->in[42] mux_2level_size50[31]->in[42] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[31]->in[43] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[31]->in[43] mux_2level_size50[31]->in[43] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[31]->in[44] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[31]->in[44] mux_2level_size50[31]->in[44] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[31]->in[45] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[31]->in[45] mux_2level_size50[31]->in[45] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[31]->in[46] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[31]->in[46] mux_2level_size50[31]->in[46] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[31]->in[47] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[31]->in[47] mux_2level_size50[31]->in[47] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[31]->in[48] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[31]->in[48] mux_2level_size50[31]->in[48] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[31]->in[49] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[31]->in[49] mux_2level_size50[31]->in[49] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
Vgvdd_mux_2level_size50[31] gvdd_mux_2level_size50[31] 0 vsp
***** Measurements *****
***** Rise delay *****
.meas tran delay_rise_idle_mux50[31]_in[1]_crossbar trig v(mux_2level_size50[31]->in[0]) val='input_thres_pct_rise*vsp' rise=1 td='clock_period'
+          targ v(mux_2level_size50[31]->out) val='output_thres_pct_rise*vsp' rise=1 td='clock_period'
***** Fall delay *****
.meas tran delay_fall_idle_mux50[31]_in[1]_crossbar trig v(mux_2level_size50[31]->in[0]) val='input_thres_pct_fall*vsp' fall=1 td='clock_period'
+          targ v(mux_2level_size50[31]->out) val='output_thres_pct_fall*vsp' fall=1 td='clock_period'
***** Rise timing period *****
.meas start_rise_idle_mux50[31]_in[1]_crossbar when v(mux_2level_size50[31]->in[0])='slew_lower_thres_pct_rise*vsp' rise=1 td='clock_period'
.meas tran switch_rise_idle_mux50[31]_in[1]_crossbar trig v(mux_2level_size50[31]->in[0]) val='slew_lower_thres_pct_rise*vsp' rise=1 td='clock_period'
+          targ v(mux_2level_size50[31]->out) val='slew_upper_thres_pct_rise*vsp' rise=1 td='clock_period'
***** Fall timing period *****
.meas start_fall_idle_mux50[31]_in[1]_crossbar when v(mux_2level_size50[31]->in[0])='slew_lower_thres_pct_fall*vsp' fall=1 td='clock_period'
.meas tran switch_fall_idle_mux50[31]_in[1]_crossbar trig v(mux_2level_size50[31]->in[0]) val='slew_lower_thres_pct_fall*vsp' fall=1 td='clock_period'
+          targ v(mux_2level_size50[31]->out) val='slew_upper_thres_pct_fall*vsp' fall=1 td='clock_period'
***** Leakage Power Measurement *****
.meas tran mux_2level_size50[31]_leakage_power avg p(Vgvdd_mux_2level_size50[31]) from=0 to='clock_period'
.meas tran leakage_idle_mux50[31]_in[1]_crossbar param='mux_2level_size50[31]_leakage_power'
***** Dynamic Power Measurement *****
.meas tran mux_2level_size50[31]_dynamic_power avg p(Vgvdd_mux_2level_size50[31]) from='clock_period' to='6*clock_period'
.meas tran mux_2level_size50[31]_energy_per_cycle param='mux_2level_size50[31]_dynamic_power*clock_period'
.meas tran dynamic_power_idle_mux50[31]_in[1]_crossbar  param='mux_2level_size50[31]_dynamic_power'
.meas tran energy_per_cycle_idle_mux50[31]_in[1]_crossbar  param='dynamic_power_idle_mux50[31]_in[1]_crossbar*clock_period'
.meas tran dynamic_rise_idle_mux50[31]_in[1]_crossbar avg p(Vgvdd_mux_2level_size50[31]) from='start_rise_idle_mux50[31]_in[1]_crossbar' to='start_rise_idle_mux50[31]_in[1]_crossbar+switch_rise_idle_mux50[31]_in[1]_crossbar'
.meas tran dynamic_fall_idle_mux50[31]_in[1]_crossbar avg p(Vgvdd_mux_2level_size50[31]) from='start_fall_idle_mux50[31]_in[1]_crossbar' to='start_fall_idle_mux50[31]_in[1]_crossbar+switch_fall_idle_mux50[31]_in[1]_crossbar'
.meas tran sum_leakage_power_mux[0to31]
+          param='sum_leakage_power_mux[0to30]+leakage_idle_mux50[31]_in[1]_crossbar'
.meas tran sum_energy_per_cycle_mux[0to31]
+          param='sum_energy_per_cycle_mux[0to30]+energy_per_cycle_idle_mux50[31]_in[1]_crossbar'
Xload_inv[31]_no0 mux_2level_size50[31]->out mux_2level_size50[31]->out_out[0] gvdd_load 0 inv size=5
.meas tran sum_leakage_power_pb_mux[0to31]
+          param='sum_leakage_power_pb_mux[0to30]+leakage_idle_mux50[31]_in[1]_crossbar'
.meas tran sum_energy_per_cycle_pb_mux[0to31]
+          param='sum_energy_per_cycle_pb_mux[0to30]+energy_per_cycle_idle_mux50[31]_in[1]_crossbar'
Xmux_2level_size50[32] mux_2level_size50[32]->in[0] mux_2level_size50[32]->in[1] mux_2level_size50[32]->in[2] mux_2level_size50[32]->in[3] mux_2level_size50[32]->in[4] mux_2level_size50[32]->in[5] mux_2level_size50[32]->in[6] mux_2level_size50[32]->in[7] mux_2level_size50[32]->in[8] mux_2level_size50[32]->in[9] mux_2level_size50[32]->in[10] mux_2level_size50[32]->in[11] mux_2level_size50[32]->in[12] mux_2level_size50[32]->in[13] mux_2level_size50[32]->in[14] mux_2level_size50[32]->in[15] mux_2level_size50[32]->in[16] mux_2level_size50[32]->in[17] mux_2level_size50[32]->in[18] mux_2level_size50[32]->in[19] mux_2level_size50[32]->in[20] mux_2level_size50[32]->in[21] mux_2level_size50[32]->in[22] mux_2level_size50[32]->in[23] mux_2level_size50[32]->in[24] mux_2level_size50[32]->in[25] mux_2level_size50[32]->in[26] mux_2level_size50[32]->in[27] mux_2level_size50[32]->in[28] mux_2level_size50[32]->in[29] mux_2level_size50[32]->in[30] mux_2level_size50[32]->in[31] mux_2level_size50[32]->in[32] mux_2level_size50[32]->in[33] mux_2level_size50[32]->in[34] mux_2level_size50[32]->in[35] mux_2level_size50[32]->in[36] mux_2level_size50[32]->in[37] mux_2level_size50[32]->in[38] mux_2level_size50[32]->in[39] mux_2level_size50[32]->in[40] mux_2level_size50[32]->in[41] mux_2level_size50[32]->in[42] mux_2level_size50[32]->in[43] mux_2level_size50[32]->in[44] mux_2level_size50[32]->in[45] mux_2level_size50[32]->in[46] mux_2level_size50[32]->in[47] mux_2level_size50[32]->in[48] mux_2level_size50[32]->in[49] mux_2level_size50[32]->out sram[512]->outb sram[512]->out sram[513]->out sram[513]->outb sram[514]->out sram[514]->outb sram[515]->out sram[515]->outb sram[516]->out sram[516]->outb sram[517]->out sram[517]->outb sram[518]->out sram[518]->outb sram[519]->out sram[519]->outb sram[520]->outb sram[520]->out sram[521]->out sram[521]->outb sram[522]->out sram[522]->outb sram[523]->out sram[523]->outb sram[524]->out sram[524]->outb sram[525]->out sram[525]->outb sram[526]->out sram[526]->outb sram[527]->out sram[527]->outb gvdd_mux_2level_size50[32] 0 mux_2level_size50
***** SRAM bits for MUX[32], level=2, select_path_id=0. *****
*****1000000010000000*****
Xsram[512] sram->in sram[512]->out sram[512]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[512]->out) 0
.nodeset V(sram[512]->outb) vsp
Xsram[513] sram->in sram[513]->out sram[513]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[513]->out) 0
.nodeset V(sram[513]->outb) vsp
Xsram[514] sram->in sram[514]->out sram[514]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[514]->out) 0
.nodeset V(sram[514]->outb) vsp
Xsram[515] sram->in sram[515]->out sram[515]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[515]->out) 0
.nodeset V(sram[515]->outb) vsp
Xsram[516] sram->in sram[516]->out sram[516]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[516]->out) 0
.nodeset V(sram[516]->outb) vsp
Xsram[517] sram->in sram[517]->out sram[517]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[517]->out) 0
.nodeset V(sram[517]->outb) vsp
Xsram[518] sram->in sram[518]->out sram[518]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[518]->out) 0
.nodeset V(sram[518]->outb) vsp
Xsram[519] sram->in sram[519]->out sram[519]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[519]->out) 0
.nodeset V(sram[519]->outb) vsp
Xsram[520] sram->in sram[520]->out sram[520]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[520]->out) 0
.nodeset V(sram[520]->outb) vsp
Xsram[521] sram->in sram[521]->out sram[521]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[521]->out) 0
.nodeset V(sram[521]->outb) vsp
Xsram[522] sram->in sram[522]->out sram[522]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[522]->out) 0
.nodeset V(sram[522]->outb) vsp
Xsram[523] sram->in sram[523]->out sram[523]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[523]->out) 0
.nodeset V(sram[523]->outb) vsp
Xsram[524] sram->in sram[524]->out sram[524]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[524]->out) 0
.nodeset V(sram[524]->outb) vsp
Xsram[525] sram->in sram[525]->out sram[525]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[525]->out) 0
.nodeset V(sram[525]->outb) vsp
Xsram[526] sram->in sram[526]->out sram[526]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[526]->out) 0
.nodeset V(sram[526]->outb) vsp
Xsram[527] sram->in sram[527]->out sram[527]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[527]->out) 0
.nodeset V(sram[527]->outb) vsp
***** Signal mux_2level_size50[32]->in[0] density = 0, probability=0.*****
Vmux_2level_size50[32]->in[0] mux_2level_size50[32]->in[0] 0
+  0
***** Signal mux_2level_size50[32]->in[1] density = 0, probability=0.*****
Vmux_2level_size50[32]->in[1] mux_2level_size50[32]->in[1] 0
+  0
***** Signal mux_2level_size50[32]->in[2] density = 0, probability=0.*****
Vmux_2level_size50[32]->in[2] mux_2level_size50[32]->in[2] 0
+  0
***** Signal mux_2level_size50[32]->in[3] density = 0, probability=0.*****
Vmux_2level_size50[32]->in[3] mux_2level_size50[32]->in[3] 0
+  0
***** Signal mux_2level_size50[32]->in[4] density = 0, probability=0.*****
Vmux_2level_size50[32]->in[4] mux_2level_size50[32]->in[4] 0
+  0
***** Signal mux_2level_size50[32]->in[5] density = 0, probability=0.*****
Vmux_2level_size50[32]->in[5] mux_2level_size50[32]->in[5] 0
+  0
***** Signal mux_2level_size50[32]->in[6] density = 0, probability=0.*****
Vmux_2level_size50[32]->in[6] mux_2level_size50[32]->in[6] 0
+  0
***** Signal mux_2level_size50[32]->in[7] density = 0, probability=0.*****
Vmux_2level_size50[32]->in[7] mux_2level_size50[32]->in[7] 0
+  0
***** Signal mux_2level_size50[32]->in[8] density = 0, probability=0.*****
Vmux_2level_size50[32]->in[8] mux_2level_size50[32]->in[8] 0
+  0
***** Signal mux_2level_size50[32]->in[9] density = 0, probability=0.*****
Vmux_2level_size50[32]->in[9] mux_2level_size50[32]->in[9] 0
+  0
***** Signal mux_2level_size50[32]->in[10] density = 0, probability=0.*****
Vmux_2level_size50[32]->in[10] mux_2level_size50[32]->in[10] 0
+  0
***** Signal mux_2level_size50[32]->in[11] density = 0, probability=0.*****
Vmux_2level_size50[32]->in[11] mux_2level_size50[32]->in[11] 0
+  0
***** Signal mux_2level_size50[32]->in[12] density = 0, probability=0.*****
Vmux_2level_size50[32]->in[12] mux_2level_size50[32]->in[12] 0
+  0
***** Signal mux_2level_size50[32]->in[13] density = 0, probability=0.*****
Vmux_2level_size50[32]->in[13] mux_2level_size50[32]->in[13] 0
+  0
***** Signal mux_2level_size50[32]->in[14] density = 0, probability=0.*****
Vmux_2level_size50[32]->in[14] mux_2level_size50[32]->in[14] 0
+  0
***** Signal mux_2level_size50[32]->in[15] density = 0, probability=0.*****
Vmux_2level_size50[32]->in[15] mux_2level_size50[32]->in[15] 0
+  0
***** Signal mux_2level_size50[32]->in[16] density = 0, probability=0.*****
Vmux_2level_size50[32]->in[16] mux_2level_size50[32]->in[16] 0
+  0
***** Signal mux_2level_size50[32]->in[17] density = 0, probability=0.*****
Vmux_2level_size50[32]->in[17] mux_2level_size50[32]->in[17] 0
+  0
***** Signal mux_2level_size50[32]->in[18] density = 0, probability=0.*****
Vmux_2level_size50[32]->in[18] mux_2level_size50[32]->in[18] 0
+  0
***** Signal mux_2level_size50[32]->in[19] density = 0, probability=0.*****
Vmux_2level_size50[32]->in[19] mux_2level_size50[32]->in[19] 0
+  0
***** Signal mux_2level_size50[32]->in[20] density = 0, probability=0.*****
Vmux_2level_size50[32]->in[20] mux_2level_size50[32]->in[20] 0
+  0
***** Signal mux_2level_size50[32]->in[21] density = 0, probability=0.*****
Vmux_2level_size50[32]->in[21] mux_2level_size50[32]->in[21] 0
+  0
***** Signal mux_2level_size50[32]->in[22] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[32]->in[22] mux_2level_size50[32]->in[22] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[32]->in[23] density = 0, probability=0.*****
Vmux_2level_size50[32]->in[23] mux_2level_size50[32]->in[23] 0
+  0
***** Signal mux_2level_size50[32]->in[24] density = 0, probability=0.*****
Vmux_2level_size50[32]->in[24] mux_2level_size50[32]->in[24] 0
+  0
***** Signal mux_2level_size50[32]->in[25] density = 0, probability=0.*****
Vmux_2level_size50[32]->in[25] mux_2level_size50[32]->in[25] 0
+  0
***** Signal mux_2level_size50[32]->in[26] density = 0, probability=0.*****
Vmux_2level_size50[32]->in[26] mux_2level_size50[32]->in[26] 0
+  0
***** Signal mux_2level_size50[32]->in[27] density = 0, probability=0.*****
Vmux_2level_size50[32]->in[27] mux_2level_size50[32]->in[27] 0
+  0
***** Signal mux_2level_size50[32]->in[28] density = 0, probability=0.*****
Vmux_2level_size50[32]->in[28] mux_2level_size50[32]->in[28] 0
+  0
***** Signal mux_2level_size50[32]->in[29] density = 0, probability=0.*****
Vmux_2level_size50[32]->in[29] mux_2level_size50[32]->in[29] 0
+  0
***** Signal mux_2level_size50[32]->in[30] density = 0, probability=0.*****
Vmux_2level_size50[32]->in[30] mux_2level_size50[32]->in[30] 0
+  0
***** Signal mux_2level_size50[32]->in[31] density = 0, probability=0.*****
Vmux_2level_size50[32]->in[31] mux_2level_size50[32]->in[31] 0
+  0
***** Signal mux_2level_size50[32]->in[32] density = 0, probability=0.*****
Vmux_2level_size50[32]->in[32] mux_2level_size50[32]->in[32] 0
+  0
***** Signal mux_2level_size50[32]->in[33] density = 0, probability=0.*****
Vmux_2level_size50[32]->in[33] mux_2level_size50[32]->in[33] 0
+  0
***** Signal mux_2level_size50[32]->in[34] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[32]->in[34] mux_2level_size50[32]->in[34] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[32]->in[35] density = 0, probability=0.*****
Vmux_2level_size50[32]->in[35] mux_2level_size50[32]->in[35] 0
+  0
***** Signal mux_2level_size50[32]->in[36] density = 0, probability=0.*****
Vmux_2level_size50[32]->in[36] mux_2level_size50[32]->in[36] 0
+  0
***** Signal mux_2level_size50[32]->in[37] density = 0, probability=0.*****
Vmux_2level_size50[32]->in[37] mux_2level_size50[32]->in[37] 0
+  0
***** Signal mux_2level_size50[32]->in[38] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[32]->in[38] mux_2level_size50[32]->in[38] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[32]->in[39] density = 0, probability=0.*****
Vmux_2level_size50[32]->in[39] mux_2level_size50[32]->in[39] 0
+  0
***** Signal mux_2level_size50[32]->in[40] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[32]->in[40] mux_2level_size50[32]->in[40] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[32]->in[41] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[32]->in[41] mux_2level_size50[32]->in[41] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[32]->in[42] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[32]->in[42] mux_2level_size50[32]->in[42] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[32]->in[43] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[32]->in[43] mux_2level_size50[32]->in[43] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[32]->in[44] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[32]->in[44] mux_2level_size50[32]->in[44] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[32]->in[45] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[32]->in[45] mux_2level_size50[32]->in[45] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[32]->in[46] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[32]->in[46] mux_2level_size50[32]->in[46] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[32]->in[47] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[32]->in[47] mux_2level_size50[32]->in[47] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[32]->in[48] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[32]->in[48] mux_2level_size50[32]->in[48] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[32]->in[49] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[32]->in[49] mux_2level_size50[32]->in[49] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
Vgvdd_mux_2level_size50[32] gvdd_mux_2level_size50[32] 0 vsp
***** Measurements *****
***** Rise delay *****
.meas tran delay_rise_idle_mux50[32]_in[2]_crossbar trig v(mux_2level_size50[32]->in[0]) val='input_thres_pct_rise*vsp' rise=1 td='clock_period'
+          targ v(mux_2level_size50[32]->out) val='output_thres_pct_rise*vsp' rise=1 td='clock_period'
***** Fall delay *****
.meas tran delay_fall_idle_mux50[32]_in[2]_crossbar trig v(mux_2level_size50[32]->in[0]) val='input_thres_pct_fall*vsp' fall=1 td='clock_period'
+          targ v(mux_2level_size50[32]->out) val='output_thres_pct_fall*vsp' fall=1 td='clock_period'
***** Rise timing period *****
.meas start_rise_idle_mux50[32]_in[2]_crossbar when v(mux_2level_size50[32]->in[0])='slew_lower_thres_pct_rise*vsp' rise=1 td='clock_period'
.meas tran switch_rise_idle_mux50[32]_in[2]_crossbar trig v(mux_2level_size50[32]->in[0]) val='slew_lower_thres_pct_rise*vsp' rise=1 td='clock_period'
+          targ v(mux_2level_size50[32]->out) val='slew_upper_thres_pct_rise*vsp' rise=1 td='clock_period'
***** Fall timing period *****
.meas start_fall_idle_mux50[32]_in[2]_crossbar when v(mux_2level_size50[32]->in[0])='slew_lower_thres_pct_fall*vsp' fall=1 td='clock_period'
.meas tran switch_fall_idle_mux50[32]_in[2]_crossbar trig v(mux_2level_size50[32]->in[0]) val='slew_lower_thres_pct_fall*vsp' fall=1 td='clock_period'
+          targ v(mux_2level_size50[32]->out) val='slew_upper_thres_pct_fall*vsp' fall=1 td='clock_period'
***** Leakage Power Measurement *****
.meas tran mux_2level_size50[32]_leakage_power avg p(Vgvdd_mux_2level_size50[32]) from=0 to='clock_period'
.meas tran leakage_idle_mux50[32]_in[2]_crossbar param='mux_2level_size50[32]_leakage_power'
***** Dynamic Power Measurement *****
.meas tran mux_2level_size50[32]_dynamic_power avg p(Vgvdd_mux_2level_size50[32]) from='clock_period' to='6*clock_period'
.meas tran mux_2level_size50[32]_energy_per_cycle param='mux_2level_size50[32]_dynamic_power*clock_period'
.meas tran dynamic_power_idle_mux50[32]_in[2]_crossbar  param='mux_2level_size50[32]_dynamic_power'
.meas tran energy_per_cycle_idle_mux50[32]_in[2]_crossbar  param='dynamic_power_idle_mux50[32]_in[2]_crossbar*clock_period'
.meas tran dynamic_rise_idle_mux50[32]_in[2]_crossbar avg p(Vgvdd_mux_2level_size50[32]) from='start_rise_idle_mux50[32]_in[2]_crossbar' to='start_rise_idle_mux50[32]_in[2]_crossbar+switch_rise_idle_mux50[32]_in[2]_crossbar'
.meas tran dynamic_fall_idle_mux50[32]_in[2]_crossbar avg p(Vgvdd_mux_2level_size50[32]) from='start_fall_idle_mux50[32]_in[2]_crossbar' to='start_fall_idle_mux50[32]_in[2]_crossbar+switch_fall_idle_mux50[32]_in[2]_crossbar'
.meas tran sum_leakage_power_mux[0to32]
+          param='sum_leakage_power_mux[0to31]+leakage_idle_mux50[32]_in[2]_crossbar'
.meas tran sum_energy_per_cycle_mux[0to32]
+          param='sum_energy_per_cycle_mux[0to31]+energy_per_cycle_idle_mux50[32]_in[2]_crossbar'
Xload_inv[32]_no0 mux_2level_size50[32]->out mux_2level_size50[32]->out_out[0] gvdd_load 0 inv size=5
.meas tran sum_leakage_power_pb_mux[0to32]
+          param='sum_leakage_power_pb_mux[0to31]+leakage_idle_mux50[32]_in[2]_crossbar'
.meas tran sum_energy_per_cycle_pb_mux[0to32]
+          param='sum_energy_per_cycle_pb_mux[0to31]+energy_per_cycle_idle_mux50[32]_in[2]_crossbar'
Xmux_2level_size50[33] mux_2level_size50[33]->in[0] mux_2level_size50[33]->in[1] mux_2level_size50[33]->in[2] mux_2level_size50[33]->in[3] mux_2level_size50[33]->in[4] mux_2level_size50[33]->in[5] mux_2level_size50[33]->in[6] mux_2level_size50[33]->in[7] mux_2level_size50[33]->in[8] mux_2level_size50[33]->in[9] mux_2level_size50[33]->in[10] mux_2level_size50[33]->in[11] mux_2level_size50[33]->in[12] mux_2level_size50[33]->in[13] mux_2level_size50[33]->in[14] mux_2level_size50[33]->in[15] mux_2level_size50[33]->in[16] mux_2level_size50[33]->in[17] mux_2level_size50[33]->in[18] mux_2level_size50[33]->in[19] mux_2level_size50[33]->in[20] mux_2level_size50[33]->in[21] mux_2level_size50[33]->in[22] mux_2level_size50[33]->in[23] mux_2level_size50[33]->in[24] mux_2level_size50[33]->in[25] mux_2level_size50[33]->in[26] mux_2level_size50[33]->in[27] mux_2level_size50[33]->in[28] mux_2level_size50[33]->in[29] mux_2level_size50[33]->in[30] mux_2level_size50[33]->in[31] mux_2level_size50[33]->in[32] mux_2level_size50[33]->in[33] mux_2level_size50[33]->in[34] mux_2level_size50[33]->in[35] mux_2level_size50[33]->in[36] mux_2level_size50[33]->in[37] mux_2level_size50[33]->in[38] mux_2level_size50[33]->in[39] mux_2level_size50[33]->in[40] mux_2level_size50[33]->in[41] mux_2level_size50[33]->in[42] mux_2level_size50[33]->in[43] mux_2level_size50[33]->in[44] mux_2level_size50[33]->in[45] mux_2level_size50[33]->in[46] mux_2level_size50[33]->in[47] mux_2level_size50[33]->in[48] mux_2level_size50[33]->in[49] mux_2level_size50[33]->out sram[528]->outb sram[528]->out sram[529]->out sram[529]->outb sram[530]->out sram[530]->outb sram[531]->out sram[531]->outb sram[532]->out sram[532]->outb sram[533]->out sram[533]->outb sram[534]->out sram[534]->outb sram[535]->out sram[535]->outb sram[536]->outb sram[536]->out sram[537]->out sram[537]->outb sram[538]->out sram[538]->outb sram[539]->out sram[539]->outb sram[540]->out sram[540]->outb sram[541]->out sram[541]->outb sram[542]->out sram[542]->outb sram[543]->out sram[543]->outb gvdd_mux_2level_size50[33] 0 mux_2level_size50
***** SRAM bits for MUX[33], level=2, select_path_id=0. *****
*****1000000010000000*****
Xsram[528] sram->in sram[528]->out sram[528]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[528]->out) 0
.nodeset V(sram[528]->outb) vsp
Xsram[529] sram->in sram[529]->out sram[529]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[529]->out) 0
.nodeset V(sram[529]->outb) vsp
Xsram[530] sram->in sram[530]->out sram[530]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[530]->out) 0
.nodeset V(sram[530]->outb) vsp
Xsram[531] sram->in sram[531]->out sram[531]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[531]->out) 0
.nodeset V(sram[531]->outb) vsp
Xsram[532] sram->in sram[532]->out sram[532]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[532]->out) 0
.nodeset V(sram[532]->outb) vsp
Xsram[533] sram->in sram[533]->out sram[533]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[533]->out) 0
.nodeset V(sram[533]->outb) vsp
Xsram[534] sram->in sram[534]->out sram[534]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[534]->out) 0
.nodeset V(sram[534]->outb) vsp
Xsram[535] sram->in sram[535]->out sram[535]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[535]->out) 0
.nodeset V(sram[535]->outb) vsp
Xsram[536] sram->in sram[536]->out sram[536]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[536]->out) 0
.nodeset V(sram[536]->outb) vsp
Xsram[537] sram->in sram[537]->out sram[537]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[537]->out) 0
.nodeset V(sram[537]->outb) vsp
Xsram[538] sram->in sram[538]->out sram[538]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[538]->out) 0
.nodeset V(sram[538]->outb) vsp
Xsram[539] sram->in sram[539]->out sram[539]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[539]->out) 0
.nodeset V(sram[539]->outb) vsp
Xsram[540] sram->in sram[540]->out sram[540]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[540]->out) 0
.nodeset V(sram[540]->outb) vsp
Xsram[541] sram->in sram[541]->out sram[541]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[541]->out) 0
.nodeset V(sram[541]->outb) vsp
Xsram[542] sram->in sram[542]->out sram[542]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[542]->out) 0
.nodeset V(sram[542]->outb) vsp
Xsram[543] sram->in sram[543]->out sram[543]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[543]->out) 0
.nodeset V(sram[543]->outb) vsp
***** Signal mux_2level_size50[33]->in[0] density = 0, probability=0.*****
Vmux_2level_size50[33]->in[0] mux_2level_size50[33]->in[0] 0
+  0
***** Signal mux_2level_size50[33]->in[1] density = 0, probability=0.*****
Vmux_2level_size50[33]->in[1] mux_2level_size50[33]->in[1] 0
+  0
***** Signal mux_2level_size50[33]->in[2] density = 0, probability=0.*****
Vmux_2level_size50[33]->in[2] mux_2level_size50[33]->in[2] 0
+  0
***** Signal mux_2level_size50[33]->in[3] density = 0, probability=0.*****
Vmux_2level_size50[33]->in[3] mux_2level_size50[33]->in[3] 0
+  0
***** Signal mux_2level_size50[33]->in[4] density = 0, probability=0.*****
Vmux_2level_size50[33]->in[4] mux_2level_size50[33]->in[4] 0
+  0
***** Signal mux_2level_size50[33]->in[5] density = 0, probability=0.*****
Vmux_2level_size50[33]->in[5] mux_2level_size50[33]->in[5] 0
+  0
***** Signal mux_2level_size50[33]->in[6] density = 0, probability=0.*****
Vmux_2level_size50[33]->in[6] mux_2level_size50[33]->in[6] 0
+  0
***** Signal mux_2level_size50[33]->in[7] density = 0, probability=0.*****
Vmux_2level_size50[33]->in[7] mux_2level_size50[33]->in[7] 0
+  0
***** Signal mux_2level_size50[33]->in[8] density = 0, probability=0.*****
Vmux_2level_size50[33]->in[8] mux_2level_size50[33]->in[8] 0
+  0
***** Signal mux_2level_size50[33]->in[9] density = 0, probability=0.*****
Vmux_2level_size50[33]->in[9] mux_2level_size50[33]->in[9] 0
+  0
***** Signal mux_2level_size50[33]->in[10] density = 0, probability=0.*****
Vmux_2level_size50[33]->in[10] mux_2level_size50[33]->in[10] 0
+  0
***** Signal mux_2level_size50[33]->in[11] density = 0, probability=0.*****
Vmux_2level_size50[33]->in[11] mux_2level_size50[33]->in[11] 0
+  0
***** Signal mux_2level_size50[33]->in[12] density = 0, probability=0.*****
Vmux_2level_size50[33]->in[12] mux_2level_size50[33]->in[12] 0
+  0
***** Signal mux_2level_size50[33]->in[13] density = 0, probability=0.*****
Vmux_2level_size50[33]->in[13] mux_2level_size50[33]->in[13] 0
+  0
***** Signal mux_2level_size50[33]->in[14] density = 0, probability=0.*****
Vmux_2level_size50[33]->in[14] mux_2level_size50[33]->in[14] 0
+  0
***** Signal mux_2level_size50[33]->in[15] density = 0, probability=0.*****
Vmux_2level_size50[33]->in[15] mux_2level_size50[33]->in[15] 0
+  0
***** Signal mux_2level_size50[33]->in[16] density = 0, probability=0.*****
Vmux_2level_size50[33]->in[16] mux_2level_size50[33]->in[16] 0
+  0
***** Signal mux_2level_size50[33]->in[17] density = 0, probability=0.*****
Vmux_2level_size50[33]->in[17] mux_2level_size50[33]->in[17] 0
+  0
***** Signal mux_2level_size50[33]->in[18] density = 0, probability=0.*****
Vmux_2level_size50[33]->in[18] mux_2level_size50[33]->in[18] 0
+  0
***** Signal mux_2level_size50[33]->in[19] density = 0, probability=0.*****
Vmux_2level_size50[33]->in[19] mux_2level_size50[33]->in[19] 0
+  0
***** Signal mux_2level_size50[33]->in[20] density = 0, probability=0.*****
Vmux_2level_size50[33]->in[20] mux_2level_size50[33]->in[20] 0
+  0
***** Signal mux_2level_size50[33]->in[21] density = 0, probability=0.*****
Vmux_2level_size50[33]->in[21] mux_2level_size50[33]->in[21] 0
+  0
***** Signal mux_2level_size50[33]->in[22] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[33]->in[22] mux_2level_size50[33]->in[22] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[33]->in[23] density = 0, probability=0.*****
Vmux_2level_size50[33]->in[23] mux_2level_size50[33]->in[23] 0
+  0
***** Signal mux_2level_size50[33]->in[24] density = 0, probability=0.*****
Vmux_2level_size50[33]->in[24] mux_2level_size50[33]->in[24] 0
+  0
***** Signal mux_2level_size50[33]->in[25] density = 0, probability=0.*****
Vmux_2level_size50[33]->in[25] mux_2level_size50[33]->in[25] 0
+  0
***** Signal mux_2level_size50[33]->in[26] density = 0, probability=0.*****
Vmux_2level_size50[33]->in[26] mux_2level_size50[33]->in[26] 0
+  0
***** Signal mux_2level_size50[33]->in[27] density = 0, probability=0.*****
Vmux_2level_size50[33]->in[27] mux_2level_size50[33]->in[27] 0
+  0
***** Signal mux_2level_size50[33]->in[28] density = 0, probability=0.*****
Vmux_2level_size50[33]->in[28] mux_2level_size50[33]->in[28] 0
+  0
***** Signal mux_2level_size50[33]->in[29] density = 0, probability=0.*****
Vmux_2level_size50[33]->in[29] mux_2level_size50[33]->in[29] 0
+  0
***** Signal mux_2level_size50[33]->in[30] density = 0, probability=0.*****
Vmux_2level_size50[33]->in[30] mux_2level_size50[33]->in[30] 0
+  0
***** Signal mux_2level_size50[33]->in[31] density = 0, probability=0.*****
Vmux_2level_size50[33]->in[31] mux_2level_size50[33]->in[31] 0
+  0
***** Signal mux_2level_size50[33]->in[32] density = 0, probability=0.*****
Vmux_2level_size50[33]->in[32] mux_2level_size50[33]->in[32] 0
+  0
***** Signal mux_2level_size50[33]->in[33] density = 0, probability=0.*****
Vmux_2level_size50[33]->in[33] mux_2level_size50[33]->in[33] 0
+  0
***** Signal mux_2level_size50[33]->in[34] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[33]->in[34] mux_2level_size50[33]->in[34] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[33]->in[35] density = 0, probability=0.*****
Vmux_2level_size50[33]->in[35] mux_2level_size50[33]->in[35] 0
+  0
***** Signal mux_2level_size50[33]->in[36] density = 0, probability=0.*****
Vmux_2level_size50[33]->in[36] mux_2level_size50[33]->in[36] 0
+  0
***** Signal mux_2level_size50[33]->in[37] density = 0, probability=0.*****
Vmux_2level_size50[33]->in[37] mux_2level_size50[33]->in[37] 0
+  0
***** Signal mux_2level_size50[33]->in[38] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[33]->in[38] mux_2level_size50[33]->in[38] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[33]->in[39] density = 0, probability=0.*****
Vmux_2level_size50[33]->in[39] mux_2level_size50[33]->in[39] 0
+  0
***** Signal mux_2level_size50[33]->in[40] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[33]->in[40] mux_2level_size50[33]->in[40] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[33]->in[41] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[33]->in[41] mux_2level_size50[33]->in[41] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[33]->in[42] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[33]->in[42] mux_2level_size50[33]->in[42] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[33]->in[43] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[33]->in[43] mux_2level_size50[33]->in[43] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[33]->in[44] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[33]->in[44] mux_2level_size50[33]->in[44] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[33]->in[45] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[33]->in[45] mux_2level_size50[33]->in[45] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[33]->in[46] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[33]->in[46] mux_2level_size50[33]->in[46] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[33]->in[47] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[33]->in[47] mux_2level_size50[33]->in[47] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[33]->in[48] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[33]->in[48] mux_2level_size50[33]->in[48] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[33]->in[49] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[33]->in[49] mux_2level_size50[33]->in[49] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
Vgvdd_mux_2level_size50[33] gvdd_mux_2level_size50[33] 0 vsp
***** Measurements *****
***** Rise delay *****
.meas tran delay_rise_idle_mux50[33]_in[3]_crossbar trig v(mux_2level_size50[33]->in[0]) val='input_thres_pct_rise*vsp' rise=1 td='clock_period'
+          targ v(mux_2level_size50[33]->out) val='output_thres_pct_rise*vsp' rise=1 td='clock_period'
***** Fall delay *****
.meas tran delay_fall_idle_mux50[33]_in[3]_crossbar trig v(mux_2level_size50[33]->in[0]) val='input_thres_pct_fall*vsp' fall=1 td='clock_period'
+          targ v(mux_2level_size50[33]->out) val='output_thres_pct_fall*vsp' fall=1 td='clock_period'
***** Rise timing period *****
.meas start_rise_idle_mux50[33]_in[3]_crossbar when v(mux_2level_size50[33]->in[0])='slew_lower_thres_pct_rise*vsp' rise=1 td='clock_period'
.meas tran switch_rise_idle_mux50[33]_in[3]_crossbar trig v(mux_2level_size50[33]->in[0]) val='slew_lower_thres_pct_rise*vsp' rise=1 td='clock_period'
+          targ v(mux_2level_size50[33]->out) val='slew_upper_thres_pct_rise*vsp' rise=1 td='clock_period'
***** Fall timing period *****
.meas start_fall_idle_mux50[33]_in[3]_crossbar when v(mux_2level_size50[33]->in[0])='slew_lower_thres_pct_fall*vsp' fall=1 td='clock_period'
.meas tran switch_fall_idle_mux50[33]_in[3]_crossbar trig v(mux_2level_size50[33]->in[0]) val='slew_lower_thres_pct_fall*vsp' fall=1 td='clock_period'
+          targ v(mux_2level_size50[33]->out) val='slew_upper_thres_pct_fall*vsp' fall=1 td='clock_period'
***** Leakage Power Measurement *****
.meas tran mux_2level_size50[33]_leakage_power avg p(Vgvdd_mux_2level_size50[33]) from=0 to='clock_period'
.meas tran leakage_idle_mux50[33]_in[3]_crossbar param='mux_2level_size50[33]_leakage_power'
***** Dynamic Power Measurement *****
.meas tran mux_2level_size50[33]_dynamic_power avg p(Vgvdd_mux_2level_size50[33]) from='clock_period' to='6*clock_period'
.meas tran mux_2level_size50[33]_energy_per_cycle param='mux_2level_size50[33]_dynamic_power*clock_period'
.meas tran dynamic_power_idle_mux50[33]_in[3]_crossbar  param='mux_2level_size50[33]_dynamic_power'
.meas tran energy_per_cycle_idle_mux50[33]_in[3]_crossbar  param='dynamic_power_idle_mux50[33]_in[3]_crossbar*clock_period'
.meas tran dynamic_rise_idle_mux50[33]_in[3]_crossbar avg p(Vgvdd_mux_2level_size50[33]) from='start_rise_idle_mux50[33]_in[3]_crossbar' to='start_rise_idle_mux50[33]_in[3]_crossbar+switch_rise_idle_mux50[33]_in[3]_crossbar'
.meas tran dynamic_fall_idle_mux50[33]_in[3]_crossbar avg p(Vgvdd_mux_2level_size50[33]) from='start_fall_idle_mux50[33]_in[3]_crossbar' to='start_fall_idle_mux50[33]_in[3]_crossbar+switch_fall_idle_mux50[33]_in[3]_crossbar'
.meas tran sum_leakage_power_mux[0to33]
+          param='sum_leakage_power_mux[0to32]+leakage_idle_mux50[33]_in[3]_crossbar'
.meas tran sum_energy_per_cycle_mux[0to33]
+          param='sum_energy_per_cycle_mux[0to32]+energy_per_cycle_idle_mux50[33]_in[3]_crossbar'
Xload_inv[33]_no0 mux_2level_size50[33]->out mux_2level_size50[33]->out_out[0] gvdd_load 0 inv size=5
.meas tran sum_leakage_power_pb_mux[0to33]
+          param='sum_leakage_power_pb_mux[0to32]+leakage_idle_mux50[33]_in[3]_crossbar'
.meas tran sum_energy_per_cycle_pb_mux[0to33]
+          param='sum_energy_per_cycle_pb_mux[0to32]+energy_per_cycle_idle_mux50[33]_in[3]_crossbar'
Xmux_2level_size50[34] mux_2level_size50[34]->in[0] mux_2level_size50[34]->in[1] mux_2level_size50[34]->in[2] mux_2level_size50[34]->in[3] mux_2level_size50[34]->in[4] mux_2level_size50[34]->in[5] mux_2level_size50[34]->in[6] mux_2level_size50[34]->in[7] mux_2level_size50[34]->in[8] mux_2level_size50[34]->in[9] mux_2level_size50[34]->in[10] mux_2level_size50[34]->in[11] mux_2level_size50[34]->in[12] mux_2level_size50[34]->in[13] mux_2level_size50[34]->in[14] mux_2level_size50[34]->in[15] mux_2level_size50[34]->in[16] mux_2level_size50[34]->in[17] mux_2level_size50[34]->in[18] mux_2level_size50[34]->in[19] mux_2level_size50[34]->in[20] mux_2level_size50[34]->in[21] mux_2level_size50[34]->in[22] mux_2level_size50[34]->in[23] mux_2level_size50[34]->in[24] mux_2level_size50[34]->in[25] mux_2level_size50[34]->in[26] mux_2level_size50[34]->in[27] mux_2level_size50[34]->in[28] mux_2level_size50[34]->in[29] mux_2level_size50[34]->in[30] mux_2level_size50[34]->in[31] mux_2level_size50[34]->in[32] mux_2level_size50[34]->in[33] mux_2level_size50[34]->in[34] mux_2level_size50[34]->in[35] mux_2level_size50[34]->in[36] mux_2level_size50[34]->in[37] mux_2level_size50[34]->in[38] mux_2level_size50[34]->in[39] mux_2level_size50[34]->in[40] mux_2level_size50[34]->in[41] mux_2level_size50[34]->in[42] mux_2level_size50[34]->in[43] mux_2level_size50[34]->in[44] mux_2level_size50[34]->in[45] mux_2level_size50[34]->in[46] mux_2level_size50[34]->in[47] mux_2level_size50[34]->in[48] mux_2level_size50[34]->in[49] mux_2level_size50[34]->out sram[544]->outb sram[544]->out sram[545]->out sram[545]->outb sram[546]->out sram[546]->outb sram[547]->out sram[547]->outb sram[548]->out sram[548]->outb sram[549]->out sram[549]->outb sram[550]->out sram[550]->outb sram[551]->out sram[551]->outb sram[552]->outb sram[552]->out sram[553]->out sram[553]->outb sram[554]->out sram[554]->outb sram[555]->out sram[555]->outb sram[556]->out sram[556]->outb sram[557]->out sram[557]->outb sram[558]->out sram[558]->outb sram[559]->out sram[559]->outb gvdd_mux_2level_size50[34] 0 mux_2level_size50
***** SRAM bits for MUX[34], level=2, select_path_id=0. *****
*****1000000010000000*****
Xsram[544] sram->in sram[544]->out sram[544]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[544]->out) 0
.nodeset V(sram[544]->outb) vsp
Xsram[545] sram->in sram[545]->out sram[545]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[545]->out) 0
.nodeset V(sram[545]->outb) vsp
Xsram[546] sram->in sram[546]->out sram[546]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[546]->out) 0
.nodeset V(sram[546]->outb) vsp
Xsram[547] sram->in sram[547]->out sram[547]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[547]->out) 0
.nodeset V(sram[547]->outb) vsp
Xsram[548] sram->in sram[548]->out sram[548]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[548]->out) 0
.nodeset V(sram[548]->outb) vsp
Xsram[549] sram->in sram[549]->out sram[549]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[549]->out) 0
.nodeset V(sram[549]->outb) vsp
Xsram[550] sram->in sram[550]->out sram[550]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[550]->out) 0
.nodeset V(sram[550]->outb) vsp
Xsram[551] sram->in sram[551]->out sram[551]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[551]->out) 0
.nodeset V(sram[551]->outb) vsp
Xsram[552] sram->in sram[552]->out sram[552]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[552]->out) 0
.nodeset V(sram[552]->outb) vsp
Xsram[553] sram->in sram[553]->out sram[553]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[553]->out) 0
.nodeset V(sram[553]->outb) vsp
Xsram[554] sram->in sram[554]->out sram[554]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[554]->out) 0
.nodeset V(sram[554]->outb) vsp
Xsram[555] sram->in sram[555]->out sram[555]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[555]->out) 0
.nodeset V(sram[555]->outb) vsp
Xsram[556] sram->in sram[556]->out sram[556]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[556]->out) 0
.nodeset V(sram[556]->outb) vsp
Xsram[557] sram->in sram[557]->out sram[557]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[557]->out) 0
.nodeset V(sram[557]->outb) vsp
Xsram[558] sram->in sram[558]->out sram[558]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[558]->out) 0
.nodeset V(sram[558]->outb) vsp
Xsram[559] sram->in sram[559]->out sram[559]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[559]->out) 0
.nodeset V(sram[559]->outb) vsp
***** Signal mux_2level_size50[34]->in[0] density = 0, probability=0.*****
Vmux_2level_size50[34]->in[0] mux_2level_size50[34]->in[0] 0
+  0
***** Signal mux_2level_size50[34]->in[1] density = 0, probability=0.*****
Vmux_2level_size50[34]->in[1] mux_2level_size50[34]->in[1] 0
+  0
***** Signal mux_2level_size50[34]->in[2] density = 0, probability=0.*****
Vmux_2level_size50[34]->in[2] mux_2level_size50[34]->in[2] 0
+  0
***** Signal mux_2level_size50[34]->in[3] density = 0, probability=0.*****
Vmux_2level_size50[34]->in[3] mux_2level_size50[34]->in[3] 0
+  0
***** Signal mux_2level_size50[34]->in[4] density = 0, probability=0.*****
Vmux_2level_size50[34]->in[4] mux_2level_size50[34]->in[4] 0
+  0
***** Signal mux_2level_size50[34]->in[5] density = 0, probability=0.*****
Vmux_2level_size50[34]->in[5] mux_2level_size50[34]->in[5] 0
+  0
***** Signal mux_2level_size50[34]->in[6] density = 0, probability=0.*****
Vmux_2level_size50[34]->in[6] mux_2level_size50[34]->in[6] 0
+  0
***** Signal mux_2level_size50[34]->in[7] density = 0, probability=0.*****
Vmux_2level_size50[34]->in[7] mux_2level_size50[34]->in[7] 0
+  0
***** Signal mux_2level_size50[34]->in[8] density = 0, probability=0.*****
Vmux_2level_size50[34]->in[8] mux_2level_size50[34]->in[8] 0
+  0
***** Signal mux_2level_size50[34]->in[9] density = 0, probability=0.*****
Vmux_2level_size50[34]->in[9] mux_2level_size50[34]->in[9] 0
+  0
***** Signal mux_2level_size50[34]->in[10] density = 0, probability=0.*****
Vmux_2level_size50[34]->in[10] mux_2level_size50[34]->in[10] 0
+  0
***** Signal mux_2level_size50[34]->in[11] density = 0, probability=0.*****
Vmux_2level_size50[34]->in[11] mux_2level_size50[34]->in[11] 0
+  0
***** Signal mux_2level_size50[34]->in[12] density = 0, probability=0.*****
Vmux_2level_size50[34]->in[12] mux_2level_size50[34]->in[12] 0
+  0
***** Signal mux_2level_size50[34]->in[13] density = 0, probability=0.*****
Vmux_2level_size50[34]->in[13] mux_2level_size50[34]->in[13] 0
+  0
***** Signal mux_2level_size50[34]->in[14] density = 0, probability=0.*****
Vmux_2level_size50[34]->in[14] mux_2level_size50[34]->in[14] 0
+  0
***** Signal mux_2level_size50[34]->in[15] density = 0, probability=0.*****
Vmux_2level_size50[34]->in[15] mux_2level_size50[34]->in[15] 0
+  0
***** Signal mux_2level_size50[34]->in[16] density = 0, probability=0.*****
Vmux_2level_size50[34]->in[16] mux_2level_size50[34]->in[16] 0
+  0
***** Signal mux_2level_size50[34]->in[17] density = 0, probability=0.*****
Vmux_2level_size50[34]->in[17] mux_2level_size50[34]->in[17] 0
+  0
***** Signal mux_2level_size50[34]->in[18] density = 0, probability=0.*****
Vmux_2level_size50[34]->in[18] mux_2level_size50[34]->in[18] 0
+  0
***** Signal mux_2level_size50[34]->in[19] density = 0, probability=0.*****
Vmux_2level_size50[34]->in[19] mux_2level_size50[34]->in[19] 0
+  0
***** Signal mux_2level_size50[34]->in[20] density = 0, probability=0.*****
Vmux_2level_size50[34]->in[20] mux_2level_size50[34]->in[20] 0
+  0
***** Signal mux_2level_size50[34]->in[21] density = 0, probability=0.*****
Vmux_2level_size50[34]->in[21] mux_2level_size50[34]->in[21] 0
+  0
***** Signal mux_2level_size50[34]->in[22] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[34]->in[22] mux_2level_size50[34]->in[22] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[34]->in[23] density = 0, probability=0.*****
Vmux_2level_size50[34]->in[23] mux_2level_size50[34]->in[23] 0
+  0
***** Signal mux_2level_size50[34]->in[24] density = 0, probability=0.*****
Vmux_2level_size50[34]->in[24] mux_2level_size50[34]->in[24] 0
+  0
***** Signal mux_2level_size50[34]->in[25] density = 0, probability=0.*****
Vmux_2level_size50[34]->in[25] mux_2level_size50[34]->in[25] 0
+  0
***** Signal mux_2level_size50[34]->in[26] density = 0, probability=0.*****
Vmux_2level_size50[34]->in[26] mux_2level_size50[34]->in[26] 0
+  0
***** Signal mux_2level_size50[34]->in[27] density = 0, probability=0.*****
Vmux_2level_size50[34]->in[27] mux_2level_size50[34]->in[27] 0
+  0
***** Signal mux_2level_size50[34]->in[28] density = 0, probability=0.*****
Vmux_2level_size50[34]->in[28] mux_2level_size50[34]->in[28] 0
+  0
***** Signal mux_2level_size50[34]->in[29] density = 0, probability=0.*****
Vmux_2level_size50[34]->in[29] mux_2level_size50[34]->in[29] 0
+  0
***** Signal mux_2level_size50[34]->in[30] density = 0, probability=0.*****
Vmux_2level_size50[34]->in[30] mux_2level_size50[34]->in[30] 0
+  0
***** Signal mux_2level_size50[34]->in[31] density = 0, probability=0.*****
Vmux_2level_size50[34]->in[31] mux_2level_size50[34]->in[31] 0
+  0
***** Signal mux_2level_size50[34]->in[32] density = 0, probability=0.*****
Vmux_2level_size50[34]->in[32] mux_2level_size50[34]->in[32] 0
+  0
***** Signal mux_2level_size50[34]->in[33] density = 0, probability=0.*****
Vmux_2level_size50[34]->in[33] mux_2level_size50[34]->in[33] 0
+  0
***** Signal mux_2level_size50[34]->in[34] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[34]->in[34] mux_2level_size50[34]->in[34] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[34]->in[35] density = 0, probability=0.*****
Vmux_2level_size50[34]->in[35] mux_2level_size50[34]->in[35] 0
+  0
***** Signal mux_2level_size50[34]->in[36] density = 0, probability=0.*****
Vmux_2level_size50[34]->in[36] mux_2level_size50[34]->in[36] 0
+  0
***** Signal mux_2level_size50[34]->in[37] density = 0, probability=0.*****
Vmux_2level_size50[34]->in[37] mux_2level_size50[34]->in[37] 0
+  0
***** Signal mux_2level_size50[34]->in[38] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[34]->in[38] mux_2level_size50[34]->in[38] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[34]->in[39] density = 0, probability=0.*****
Vmux_2level_size50[34]->in[39] mux_2level_size50[34]->in[39] 0
+  0
***** Signal mux_2level_size50[34]->in[40] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[34]->in[40] mux_2level_size50[34]->in[40] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[34]->in[41] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[34]->in[41] mux_2level_size50[34]->in[41] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[34]->in[42] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[34]->in[42] mux_2level_size50[34]->in[42] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[34]->in[43] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[34]->in[43] mux_2level_size50[34]->in[43] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[34]->in[44] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[34]->in[44] mux_2level_size50[34]->in[44] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[34]->in[45] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[34]->in[45] mux_2level_size50[34]->in[45] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[34]->in[46] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[34]->in[46] mux_2level_size50[34]->in[46] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[34]->in[47] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[34]->in[47] mux_2level_size50[34]->in[47] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[34]->in[48] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[34]->in[48] mux_2level_size50[34]->in[48] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[34]->in[49] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[34]->in[49] mux_2level_size50[34]->in[49] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
Vgvdd_mux_2level_size50[34] gvdd_mux_2level_size50[34] 0 vsp
***** Measurements *****
***** Rise delay *****
.meas tran delay_rise_idle_mux50[34]_in[4]_crossbar trig v(mux_2level_size50[34]->in[0]) val='input_thres_pct_rise*vsp' rise=1 td='clock_period'
+          targ v(mux_2level_size50[34]->out) val='output_thres_pct_rise*vsp' rise=1 td='clock_period'
***** Fall delay *****
.meas tran delay_fall_idle_mux50[34]_in[4]_crossbar trig v(mux_2level_size50[34]->in[0]) val='input_thres_pct_fall*vsp' fall=1 td='clock_period'
+          targ v(mux_2level_size50[34]->out) val='output_thres_pct_fall*vsp' fall=1 td='clock_period'
***** Rise timing period *****
.meas start_rise_idle_mux50[34]_in[4]_crossbar when v(mux_2level_size50[34]->in[0])='slew_lower_thres_pct_rise*vsp' rise=1 td='clock_period'
.meas tran switch_rise_idle_mux50[34]_in[4]_crossbar trig v(mux_2level_size50[34]->in[0]) val='slew_lower_thres_pct_rise*vsp' rise=1 td='clock_period'
+          targ v(mux_2level_size50[34]->out) val='slew_upper_thres_pct_rise*vsp' rise=1 td='clock_period'
***** Fall timing period *****
.meas start_fall_idle_mux50[34]_in[4]_crossbar when v(mux_2level_size50[34]->in[0])='slew_lower_thres_pct_fall*vsp' fall=1 td='clock_period'
.meas tran switch_fall_idle_mux50[34]_in[4]_crossbar trig v(mux_2level_size50[34]->in[0]) val='slew_lower_thres_pct_fall*vsp' fall=1 td='clock_period'
+          targ v(mux_2level_size50[34]->out) val='slew_upper_thres_pct_fall*vsp' fall=1 td='clock_period'
***** Leakage Power Measurement *****
.meas tran mux_2level_size50[34]_leakage_power avg p(Vgvdd_mux_2level_size50[34]) from=0 to='clock_period'
.meas tran leakage_idle_mux50[34]_in[4]_crossbar param='mux_2level_size50[34]_leakage_power'
***** Dynamic Power Measurement *****
.meas tran mux_2level_size50[34]_dynamic_power avg p(Vgvdd_mux_2level_size50[34]) from='clock_period' to='6*clock_period'
.meas tran mux_2level_size50[34]_energy_per_cycle param='mux_2level_size50[34]_dynamic_power*clock_period'
.meas tran dynamic_power_idle_mux50[34]_in[4]_crossbar  param='mux_2level_size50[34]_dynamic_power'
.meas tran energy_per_cycle_idle_mux50[34]_in[4]_crossbar  param='dynamic_power_idle_mux50[34]_in[4]_crossbar*clock_period'
.meas tran dynamic_rise_idle_mux50[34]_in[4]_crossbar avg p(Vgvdd_mux_2level_size50[34]) from='start_rise_idle_mux50[34]_in[4]_crossbar' to='start_rise_idle_mux50[34]_in[4]_crossbar+switch_rise_idle_mux50[34]_in[4]_crossbar'
.meas tran dynamic_fall_idle_mux50[34]_in[4]_crossbar avg p(Vgvdd_mux_2level_size50[34]) from='start_fall_idle_mux50[34]_in[4]_crossbar' to='start_fall_idle_mux50[34]_in[4]_crossbar+switch_fall_idle_mux50[34]_in[4]_crossbar'
.meas tran sum_leakage_power_mux[0to34]
+          param='sum_leakage_power_mux[0to33]+leakage_idle_mux50[34]_in[4]_crossbar'
.meas tran sum_energy_per_cycle_mux[0to34]
+          param='sum_energy_per_cycle_mux[0to33]+energy_per_cycle_idle_mux50[34]_in[4]_crossbar'
Xload_inv[34]_no0 mux_2level_size50[34]->out mux_2level_size50[34]->out_out[0] gvdd_load 0 inv size=5
.meas tran sum_leakage_power_pb_mux[0to34]
+          param='sum_leakage_power_pb_mux[0to33]+leakage_idle_mux50[34]_in[4]_crossbar'
.meas tran sum_energy_per_cycle_pb_mux[0to34]
+          param='sum_energy_per_cycle_pb_mux[0to33]+energy_per_cycle_idle_mux50[34]_in[4]_crossbar'
Xmux_2level_size50[35] mux_2level_size50[35]->in[0] mux_2level_size50[35]->in[1] mux_2level_size50[35]->in[2] mux_2level_size50[35]->in[3] mux_2level_size50[35]->in[4] mux_2level_size50[35]->in[5] mux_2level_size50[35]->in[6] mux_2level_size50[35]->in[7] mux_2level_size50[35]->in[8] mux_2level_size50[35]->in[9] mux_2level_size50[35]->in[10] mux_2level_size50[35]->in[11] mux_2level_size50[35]->in[12] mux_2level_size50[35]->in[13] mux_2level_size50[35]->in[14] mux_2level_size50[35]->in[15] mux_2level_size50[35]->in[16] mux_2level_size50[35]->in[17] mux_2level_size50[35]->in[18] mux_2level_size50[35]->in[19] mux_2level_size50[35]->in[20] mux_2level_size50[35]->in[21] mux_2level_size50[35]->in[22] mux_2level_size50[35]->in[23] mux_2level_size50[35]->in[24] mux_2level_size50[35]->in[25] mux_2level_size50[35]->in[26] mux_2level_size50[35]->in[27] mux_2level_size50[35]->in[28] mux_2level_size50[35]->in[29] mux_2level_size50[35]->in[30] mux_2level_size50[35]->in[31] mux_2level_size50[35]->in[32] mux_2level_size50[35]->in[33] mux_2level_size50[35]->in[34] mux_2level_size50[35]->in[35] mux_2level_size50[35]->in[36] mux_2level_size50[35]->in[37] mux_2level_size50[35]->in[38] mux_2level_size50[35]->in[39] mux_2level_size50[35]->in[40] mux_2level_size50[35]->in[41] mux_2level_size50[35]->in[42] mux_2level_size50[35]->in[43] mux_2level_size50[35]->in[44] mux_2level_size50[35]->in[45] mux_2level_size50[35]->in[46] mux_2level_size50[35]->in[47] mux_2level_size50[35]->in[48] mux_2level_size50[35]->in[49] mux_2level_size50[35]->out sram[560]->outb sram[560]->out sram[561]->out sram[561]->outb sram[562]->out sram[562]->outb sram[563]->out sram[563]->outb sram[564]->out sram[564]->outb sram[565]->out sram[565]->outb sram[566]->out sram[566]->outb sram[567]->out sram[567]->outb sram[568]->outb sram[568]->out sram[569]->out sram[569]->outb sram[570]->out sram[570]->outb sram[571]->out sram[571]->outb sram[572]->out sram[572]->outb sram[573]->out sram[573]->outb sram[574]->out sram[574]->outb sram[575]->out sram[575]->outb gvdd_mux_2level_size50[35] 0 mux_2level_size50
***** SRAM bits for MUX[35], level=2, select_path_id=0. *****
*****1000000010000000*****
Xsram[560] sram->in sram[560]->out sram[560]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[560]->out) 0
.nodeset V(sram[560]->outb) vsp
Xsram[561] sram->in sram[561]->out sram[561]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[561]->out) 0
.nodeset V(sram[561]->outb) vsp
Xsram[562] sram->in sram[562]->out sram[562]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[562]->out) 0
.nodeset V(sram[562]->outb) vsp
Xsram[563] sram->in sram[563]->out sram[563]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[563]->out) 0
.nodeset V(sram[563]->outb) vsp
Xsram[564] sram->in sram[564]->out sram[564]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[564]->out) 0
.nodeset V(sram[564]->outb) vsp
Xsram[565] sram->in sram[565]->out sram[565]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[565]->out) 0
.nodeset V(sram[565]->outb) vsp
Xsram[566] sram->in sram[566]->out sram[566]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[566]->out) 0
.nodeset V(sram[566]->outb) vsp
Xsram[567] sram->in sram[567]->out sram[567]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[567]->out) 0
.nodeset V(sram[567]->outb) vsp
Xsram[568] sram->in sram[568]->out sram[568]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[568]->out) 0
.nodeset V(sram[568]->outb) vsp
Xsram[569] sram->in sram[569]->out sram[569]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[569]->out) 0
.nodeset V(sram[569]->outb) vsp
Xsram[570] sram->in sram[570]->out sram[570]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[570]->out) 0
.nodeset V(sram[570]->outb) vsp
Xsram[571] sram->in sram[571]->out sram[571]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[571]->out) 0
.nodeset V(sram[571]->outb) vsp
Xsram[572] sram->in sram[572]->out sram[572]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[572]->out) 0
.nodeset V(sram[572]->outb) vsp
Xsram[573] sram->in sram[573]->out sram[573]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[573]->out) 0
.nodeset V(sram[573]->outb) vsp
Xsram[574] sram->in sram[574]->out sram[574]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[574]->out) 0
.nodeset V(sram[574]->outb) vsp
Xsram[575] sram->in sram[575]->out sram[575]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[575]->out) 0
.nodeset V(sram[575]->outb) vsp
***** Signal mux_2level_size50[35]->in[0] density = 0, probability=0.*****
Vmux_2level_size50[35]->in[0] mux_2level_size50[35]->in[0] 0
+  0
***** Signal mux_2level_size50[35]->in[1] density = 0, probability=0.*****
Vmux_2level_size50[35]->in[1] mux_2level_size50[35]->in[1] 0
+  0
***** Signal mux_2level_size50[35]->in[2] density = 0, probability=0.*****
Vmux_2level_size50[35]->in[2] mux_2level_size50[35]->in[2] 0
+  0
***** Signal mux_2level_size50[35]->in[3] density = 0, probability=0.*****
Vmux_2level_size50[35]->in[3] mux_2level_size50[35]->in[3] 0
+  0
***** Signal mux_2level_size50[35]->in[4] density = 0, probability=0.*****
Vmux_2level_size50[35]->in[4] mux_2level_size50[35]->in[4] 0
+  0
***** Signal mux_2level_size50[35]->in[5] density = 0, probability=0.*****
Vmux_2level_size50[35]->in[5] mux_2level_size50[35]->in[5] 0
+  0
***** Signal mux_2level_size50[35]->in[6] density = 0, probability=0.*****
Vmux_2level_size50[35]->in[6] mux_2level_size50[35]->in[6] 0
+  0
***** Signal mux_2level_size50[35]->in[7] density = 0, probability=0.*****
Vmux_2level_size50[35]->in[7] mux_2level_size50[35]->in[7] 0
+  0
***** Signal mux_2level_size50[35]->in[8] density = 0, probability=0.*****
Vmux_2level_size50[35]->in[8] mux_2level_size50[35]->in[8] 0
+  0
***** Signal mux_2level_size50[35]->in[9] density = 0, probability=0.*****
Vmux_2level_size50[35]->in[9] mux_2level_size50[35]->in[9] 0
+  0
***** Signal mux_2level_size50[35]->in[10] density = 0, probability=0.*****
Vmux_2level_size50[35]->in[10] mux_2level_size50[35]->in[10] 0
+  0
***** Signal mux_2level_size50[35]->in[11] density = 0, probability=0.*****
Vmux_2level_size50[35]->in[11] mux_2level_size50[35]->in[11] 0
+  0
***** Signal mux_2level_size50[35]->in[12] density = 0, probability=0.*****
Vmux_2level_size50[35]->in[12] mux_2level_size50[35]->in[12] 0
+  0
***** Signal mux_2level_size50[35]->in[13] density = 0, probability=0.*****
Vmux_2level_size50[35]->in[13] mux_2level_size50[35]->in[13] 0
+  0
***** Signal mux_2level_size50[35]->in[14] density = 0, probability=0.*****
Vmux_2level_size50[35]->in[14] mux_2level_size50[35]->in[14] 0
+  0
***** Signal mux_2level_size50[35]->in[15] density = 0, probability=0.*****
Vmux_2level_size50[35]->in[15] mux_2level_size50[35]->in[15] 0
+  0
***** Signal mux_2level_size50[35]->in[16] density = 0, probability=0.*****
Vmux_2level_size50[35]->in[16] mux_2level_size50[35]->in[16] 0
+  0
***** Signal mux_2level_size50[35]->in[17] density = 0, probability=0.*****
Vmux_2level_size50[35]->in[17] mux_2level_size50[35]->in[17] 0
+  0
***** Signal mux_2level_size50[35]->in[18] density = 0, probability=0.*****
Vmux_2level_size50[35]->in[18] mux_2level_size50[35]->in[18] 0
+  0
***** Signal mux_2level_size50[35]->in[19] density = 0, probability=0.*****
Vmux_2level_size50[35]->in[19] mux_2level_size50[35]->in[19] 0
+  0
***** Signal mux_2level_size50[35]->in[20] density = 0, probability=0.*****
Vmux_2level_size50[35]->in[20] mux_2level_size50[35]->in[20] 0
+  0
***** Signal mux_2level_size50[35]->in[21] density = 0, probability=0.*****
Vmux_2level_size50[35]->in[21] mux_2level_size50[35]->in[21] 0
+  0
***** Signal mux_2level_size50[35]->in[22] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[35]->in[22] mux_2level_size50[35]->in[22] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[35]->in[23] density = 0, probability=0.*****
Vmux_2level_size50[35]->in[23] mux_2level_size50[35]->in[23] 0
+  0
***** Signal mux_2level_size50[35]->in[24] density = 0, probability=0.*****
Vmux_2level_size50[35]->in[24] mux_2level_size50[35]->in[24] 0
+  0
***** Signal mux_2level_size50[35]->in[25] density = 0, probability=0.*****
Vmux_2level_size50[35]->in[25] mux_2level_size50[35]->in[25] 0
+  0
***** Signal mux_2level_size50[35]->in[26] density = 0, probability=0.*****
Vmux_2level_size50[35]->in[26] mux_2level_size50[35]->in[26] 0
+  0
***** Signal mux_2level_size50[35]->in[27] density = 0, probability=0.*****
Vmux_2level_size50[35]->in[27] mux_2level_size50[35]->in[27] 0
+  0
***** Signal mux_2level_size50[35]->in[28] density = 0, probability=0.*****
Vmux_2level_size50[35]->in[28] mux_2level_size50[35]->in[28] 0
+  0
***** Signal mux_2level_size50[35]->in[29] density = 0, probability=0.*****
Vmux_2level_size50[35]->in[29] mux_2level_size50[35]->in[29] 0
+  0
***** Signal mux_2level_size50[35]->in[30] density = 0, probability=0.*****
Vmux_2level_size50[35]->in[30] mux_2level_size50[35]->in[30] 0
+  0
***** Signal mux_2level_size50[35]->in[31] density = 0, probability=0.*****
Vmux_2level_size50[35]->in[31] mux_2level_size50[35]->in[31] 0
+  0
***** Signal mux_2level_size50[35]->in[32] density = 0, probability=0.*****
Vmux_2level_size50[35]->in[32] mux_2level_size50[35]->in[32] 0
+  0
***** Signal mux_2level_size50[35]->in[33] density = 0, probability=0.*****
Vmux_2level_size50[35]->in[33] mux_2level_size50[35]->in[33] 0
+  0
***** Signal mux_2level_size50[35]->in[34] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[35]->in[34] mux_2level_size50[35]->in[34] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[35]->in[35] density = 0, probability=0.*****
Vmux_2level_size50[35]->in[35] mux_2level_size50[35]->in[35] 0
+  0
***** Signal mux_2level_size50[35]->in[36] density = 0, probability=0.*****
Vmux_2level_size50[35]->in[36] mux_2level_size50[35]->in[36] 0
+  0
***** Signal mux_2level_size50[35]->in[37] density = 0, probability=0.*****
Vmux_2level_size50[35]->in[37] mux_2level_size50[35]->in[37] 0
+  0
***** Signal mux_2level_size50[35]->in[38] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[35]->in[38] mux_2level_size50[35]->in[38] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[35]->in[39] density = 0, probability=0.*****
Vmux_2level_size50[35]->in[39] mux_2level_size50[35]->in[39] 0
+  0
***** Signal mux_2level_size50[35]->in[40] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[35]->in[40] mux_2level_size50[35]->in[40] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[35]->in[41] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[35]->in[41] mux_2level_size50[35]->in[41] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[35]->in[42] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[35]->in[42] mux_2level_size50[35]->in[42] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[35]->in[43] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[35]->in[43] mux_2level_size50[35]->in[43] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[35]->in[44] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[35]->in[44] mux_2level_size50[35]->in[44] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[35]->in[45] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[35]->in[45] mux_2level_size50[35]->in[45] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[35]->in[46] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[35]->in[46] mux_2level_size50[35]->in[46] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[35]->in[47] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[35]->in[47] mux_2level_size50[35]->in[47] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[35]->in[48] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[35]->in[48] mux_2level_size50[35]->in[48] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[35]->in[49] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[35]->in[49] mux_2level_size50[35]->in[49] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
Vgvdd_mux_2level_size50[35] gvdd_mux_2level_size50[35] 0 vsp
***** Measurements *****
***** Rise delay *****
.meas tran delay_rise_idle_mux50[35]_in[5]_crossbar trig v(mux_2level_size50[35]->in[0]) val='input_thres_pct_rise*vsp' rise=1 td='clock_period'
+          targ v(mux_2level_size50[35]->out) val='output_thres_pct_rise*vsp' rise=1 td='clock_period'
***** Fall delay *****
.meas tran delay_fall_idle_mux50[35]_in[5]_crossbar trig v(mux_2level_size50[35]->in[0]) val='input_thres_pct_fall*vsp' fall=1 td='clock_period'
+          targ v(mux_2level_size50[35]->out) val='output_thres_pct_fall*vsp' fall=1 td='clock_period'
***** Rise timing period *****
.meas start_rise_idle_mux50[35]_in[5]_crossbar when v(mux_2level_size50[35]->in[0])='slew_lower_thres_pct_rise*vsp' rise=1 td='clock_period'
.meas tran switch_rise_idle_mux50[35]_in[5]_crossbar trig v(mux_2level_size50[35]->in[0]) val='slew_lower_thres_pct_rise*vsp' rise=1 td='clock_period'
+          targ v(mux_2level_size50[35]->out) val='slew_upper_thres_pct_rise*vsp' rise=1 td='clock_period'
***** Fall timing period *****
.meas start_fall_idle_mux50[35]_in[5]_crossbar when v(mux_2level_size50[35]->in[0])='slew_lower_thres_pct_fall*vsp' fall=1 td='clock_period'
.meas tran switch_fall_idle_mux50[35]_in[5]_crossbar trig v(mux_2level_size50[35]->in[0]) val='slew_lower_thres_pct_fall*vsp' fall=1 td='clock_period'
+          targ v(mux_2level_size50[35]->out) val='slew_upper_thres_pct_fall*vsp' fall=1 td='clock_period'
***** Leakage Power Measurement *****
.meas tran mux_2level_size50[35]_leakage_power avg p(Vgvdd_mux_2level_size50[35]) from=0 to='clock_period'
.meas tran leakage_idle_mux50[35]_in[5]_crossbar param='mux_2level_size50[35]_leakage_power'
***** Dynamic Power Measurement *****
.meas tran mux_2level_size50[35]_dynamic_power avg p(Vgvdd_mux_2level_size50[35]) from='clock_period' to='6*clock_period'
.meas tran mux_2level_size50[35]_energy_per_cycle param='mux_2level_size50[35]_dynamic_power*clock_period'
.meas tran dynamic_power_idle_mux50[35]_in[5]_crossbar  param='mux_2level_size50[35]_dynamic_power'
.meas tran energy_per_cycle_idle_mux50[35]_in[5]_crossbar  param='dynamic_power_idle_mux50[35]_in[5]_crossbar*clock_period'
.meas tran dynamic_rise_idle_mux50[35]_in[5]_crossbar avg p(Vgvdd_mux_2level_size50[35]) from='start_rise_idle_mux50[35]_in[5]_crossbar' to='start_rise_idle_mux50[35]_in[5]_crossbar+switch_rise_idle_mux50[35]_in[5]_crossbar'
.meas tran dynamic_fall_idle_mux50[35]_in[5]_crossbar avg p(Vgvdd_mux_2level_size50[35]) from='start_fall_idle_mux50[35]_in[5]_crossbar' to='start_fall_idle_mux50[35]_in[5]_crossbar+switch_fall_idle_mux50[35]_in[5]_crossbar'
.meas tran sum_leakage_power_mux[0to35]
+          param='sum_leakage_power_mux[0to34]+leakage_idle_mux50[35]_in[5]_crossbar'
.meas tran sum_energy_per_cycle_mux[0to35]
+          param='sum_energy_per_cycle_mux[0to34]+energy_per_cycle_idle_mux50[35]_in[5]_crossbar'
Xload_inv[35]_no0 mux_2level_size50[35]->out mux_2level_size50[35]->out_out[0] gvdd_load 0 inv size=5
.meas tran sum_leakage_power_pb_mux[0to35]
+          param='sum_leakage_power_pb_mux[0to34]+leakage_idle_mux50[35]_in[5]_crossbar'
.meas tran sum_energy_per_cycle_pb_mux[0to35]
+          param='sum_energy_per_cycle_pb_mux[0to34]+energy_per_cycle_idle_mux50[35]_in[5]_crossbar'
Xmux_2level_size50[36] mux_2level_size50[36]->in[0] mux_2level_size50[36]->in[1] mux_2level_size50[36]->in[2] mux_2level_size50[36]->in[3] mux_2level_size50[36]->in[4] mux_2level_size50[36]->in[5] mux_2level_size50[36]->in[6] mux_2level_size50[36]->in[7] mux_2level_size50[36]->in[8] mux_2level_size50[36]->in[9] mux_2level_size50[36]->in[10] mux_2level_size50[36]->in[11] mux_2level_size50[36]->in[12] mux_2level_size50[36]->in[13] mux_2level_size50[36]->in[14] mux_2level_size50[36]->in[15] mux_2level_size50[36]->in[16] mux_2level_size50[36]->in[17] mux_2level_size50[36]->in[18] mux_2level_size50[36]->in[19] mux_2level_size50[36]->in[20] mux_2level_size50[36]->in[21] mux_2level_size50[36]->in[22] mux_2level_size50[36]->in[23] mux_2level_size50[36]->in[24] mux_2level_size50[36]->in[25] mux_2level_size50[36]->in[26] mux_2level_size50[36]->in[27] mux_2level_size50[36]->in[28] mux_2level_size50[36]->in[29] mux_2level_size50[36]->in[30] mux_2level_size50[36]->in[31] mux_2level_size50[36]->in[32] mux_2level_size50[36]->in[33] mux_2level_size50[36]->in[34] mux_2level_size50[36]->in[35] mux_2level_size50[36]->in[36] mux_2level_size50[36]->in[37] mux_2level_size50[36]->in[38] mux_2level_size50[36]->in[39] mux_2level_size50[36]->in[40] mux_2level_size50[36]->in[41] mux_2level_size50[36]->in[42] mux_2level_size50[36]->in[43] mux_2level_size50[36]->in[44] mux_2level_size50[36]->in[45] mux_2level_size50[36]->in[46] mux_2level_size50[36]->in[47] mux_2level_size50[36]->in[48] mux_2level_size50[36]->in[49] mux_2level_size50[36]->out sram[576]->outb sram[576]->out sram[577]->out sram[577]->outb sram[578]->out sram[578]->outb sram[579]->out sram[579]->outb sram[580]->out sram[580]->outb sram[581]->out sram[581]->outb sram[582]->out sram[582]->outb sram[583]->out sram[583]->outb sram[584]->outb sram[584]->out sram[585]->out sram[585]->outb sram[586]->out sram[586]->outb sram[587]->out sram[587]->outb sram[588]->out sram[588]->outb sram[589]->out sram[589]->outb sram[590]->out sram[590]->outb sram[591]->out sram[591]->outb gvdd_mux_2level_size50[36] 0 mux_2level_size50
***** SRAM bits for MUX[36], level=2, select_path_id=0. *****
*****1000000010000000*****
Xsram[576] sram->in sram[576]->out sram[576]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[576]->out) 0
.nodeset V(sram[576]->outb) vsp
Xsram[577] sram->in sram[577]->out sram[577]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[577]->out) 0
.nodeset V(sram[577]->outb) vsp
Xsram[578] sram->in sram[578]->out sram[578]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[578]->out) 0
.nodeset V(sram[578]->outb) vsp
Xsram[579] sram->in sram[579]->out sram[579]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[579]->out) 0
.nodeset V(sram[579]->outb) vsp
Xsram[580] sram->in sram[580]->out sram[580]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[580]->out) 0
.nodeset V(sram[580]->outb) vsp
Xsram[581] sram->in sram[581]->out sram[581]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[581]->out) 0
.nodeset V(sram[581]->outb) vsp
Xsram[582] sram->in sram[582]->out sram[582]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[582]->out) 0
.nodeset V(sram[582]->outb) vsp
Xsram[583] sram->in sram[583]->out sram[583]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[583]->out) 0
.nodeset V(sram[583]->outb) vsp
Xsram[584] sram->in sram[584]->out sram[584]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[584]->out) 0
.nodeset V(sram[584]->outb) vsp
Xsram[585] sram->in sram[585]->out sram[585]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[585]->out) 0
.nodeset V(sram[585]->outb) vsp
Xsram[586] sram->in sram[586]->out sram[586]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[586]->out) 0
.nodeset V(sram[586]->outb) vsp
Xsram[587] sram->in sram[587]->out sram[587]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[587]->out) 0
.nodeset V(sram[587]->outb) vsp
Xsram[588] sram->in sram[588]->out sram[588]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[588]->out) 0
.nodeset V(sram[588]->outb) vsp
Xsram[589] sram->in sram[589]->out sram[589]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[589]->out) 0
.nodeset V(sram[589]->outb) vsp
Xsram[590] sram->in sram[590]->out sram[590]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[590]->out) 0
.nodeset V(sram[590]->outb) vsp
Xsram[591] sram->in sram[591]->out sram[591]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[591]->out) 0
.nodeset V(sram[591]->outb) vsp
***** Signal mux_2level_size50[36]->in[0] density = 0, probability=0.*****
Vmux_2level_size50[36]->in[0] mux_2level_size50[36]->in[0] 0
+  0
***** Signal mux_2level_size50[36]->in[1] density = 0, probability=0.*****
Vmux_2level_size50[36]->in[1] mux_2level_size50[36]->in[1] 0
+  0
***** Signal mux_2level_size50[36]->in[2] density = 0, probability=0.*****
Vmux_2level_size50[36]->in[2] mux_2level_size50[36]->in[2] 0
+  0
***** Signal mux_2level_size50[36]->in[3] density = 0, probability=0.*****
Vmux_2level_size50[36]->in[3] mux_2level_size50[36]->in[3] 0
+  0
***** Signal mux_2level_size50[36]->in[4] density = 0, probability=0.*****
Vmux_2level_size50[36]->in[4] mux_2level_size50[36]->in[4] 0
+  0
***** Signal mux_2level_size50[36]->in[5] density = 0, probability=0.*****
Vmux_2level_size50[36]->in[5] mux_2level_size50[36]->in[5] 0
+  0
***** Signal mux_2level_size50[36]->in[6] density = 0, probability=0.*****
Vmux_2level_size50[36]->in[6] mux_2level_size50[36]->in[6] 0
+  0
***** Signal mux_2level_size50[36]->in[7] density = 0, probability=0.*****
Vmux_2level_size50[36]->in[7] mux_2level_size50[36]->in[7] 0
+  0
***** Signal mux_2level_size50[36]->in[8] density = 0, probability=0.*****
Vmux_2level_size50[36]->in[8] mux_2level_size50[36]->in[8] 0
+  0
***** Signal mux_2level_size50[36]->in[9] density = 0, probability=0.*****
Vmux_2level_size50[36]->in[9] mux_2level_size50[36]->in[9] 0
+  0
***** Signal mux_2level_size50[36]->in[10] density = 0, probability=0.*****
Vmux_2level_size50[36]->in[10] mux_2level_size50[36]->in[10] 0
+  0
***** Signal mux_2level_size50[36]->in[11] density = 0, probability=0.*****
Vmux_2level_size50[36]->in[11] mux_2level_size50[36]->in[11] 0
+  0
***** Signal mux_2level_size50[36]->in[12] density = 0, probability=0.*****
Vmux_2level_size50[36]->in[12] mux_2level_size50[36]->in[12] 0
+  0
***** Signal mux_2level_size50[36]->in[13] density = 0, probability=0.*****
Vmux_2level_size50[36]->in[13] mux_2level_size50[36]->in[13] 0
+  0
***** Signal mux_2level_size50[36]->in[14] density = 0, probability=0.*****
Vmux_2level_size50[36]->in[14] mux_2level_size50[36]->in[14] 0
+  0
***** Signal mux_2level_size50[36]->in[15] density = 0, probability=0.*****
Vmux_2level_size50[36]->in[15] mux_2level_size50[36]->in[15] 0
+  0
***** Signal mux_2level_size50[36]->in[16] density = 0, probability=0.*****
Vmux_2level_size50[36]->in[16] mux_2level_size50[36]->in[16] 0
+  0
***** Signal mux_2level_size50[36]->in[17] density = 0, probability=0.*****
Vmux_2level_size50[36]->in[17] mux_2level_size50[36]->in[17] 0
+  0
***** Signal mux_2level_size50[36]->in[18] density = 0, probability=0.*****
Vmux_2level_size50[36]->in[18] mux_2level_size50[36]->in[18] 0
+  0
***** Signal mux_2level_size50[36]->in[19] density = 0, probability=0.*****
Vmux_2level_size50[36]->in[19] mux_2level_size50[36]->in[19] 0
+  0
***** Signal mux_2level_size50[36]->in[20] density = 0, probability=0.*****
Vmux_2level_size50[36]->in[20] mux_2level_size50[36]->in[20] 0
+  0
***** Signal mux_2level_size50[36]->in[21] density = 0, probability=0.*****
Vmux_2level_size50[36]->in[21] mux_2level_size50[36]->in[21] 0
+  0
***** Signal mux_2level_size50[36]->in[22] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[36]->in[22] mux_2level_size50[36]->in[22] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[36]->in[23] density = 0, probability=0.*****
Vmux_2level_size50[36]->in[23] mux_2level_size50[36]->in[23] 0
+  0
***** Signal mux_2level_size50[36]->in[24] density = 0, probability=0.*****
Vmux_2level_size50[36]->in[24] mux_2level_size50[36]->in[24] 0
+  0
***** Signal mux_2level_size50[36]->in[25] density = 0, probability=0.*****
Vmux_2level_size50[36]->in[25] mux_2level_size50[36]->in[25] 0
+  0
***** Signal mux_2level_size50[36]->in[26] density = 0, probability=0.*****
Vmux_2level_size50[36]->in[26] mux_2level_size50[36]->in[26] 0
+  0
***** Signal mux_2level_size50[36]->in[27] density = 0, probability=0.*****
Vmux_2level_size50[36]->in[27] mux_2level_size50[36]->in[27] 0
+  0
***** Signal mux_2level_size50[36]->in[28] density = 0, probability=0.*****
Vmux_2level_size50[36]->in[28] mux_2level_size50[36]->in[28] 0
+  0
***** Signal mux_2level_size50[36]->in[29] density = 0, probability=0.*****
Vmux_2level_size50[36]->in[29] mux_2level_size50[36]->in[29] 0
+  0
***** Signal mux_2level_size50[36]->in[30] density = 0, probability=0.*****
Vmux_2level_size50[36]->in[30] mux_2level_size50[36]->in[30] 0
+  0
***** Signal mux_2level_size50[36]->in[31] density = 0, probability=0.*****
Vmux_2level_size50[36]->in[31] mux_2level_size50[36]->in[31] 0
+  0
***** Signal mux_2level_size50[36]->in[32] density = 0, probability=0.*****
Vmux_2level_size50[36]->in[32] mux_2level_size50[36]->in[32] 0
+  0
***** Signal mux_2level_size50[36]->in[33] density = 0, probability=0.*****
Vmux_2level_size50[36]->in[33] mux_2level_size50[36]->in[33] 0
+  0
***** Signal mux_2level_size50[36]->in[34] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[36]->in[34] mux_2level_size50[36]->in[34] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[36]->in[35] density = 0, probability=0.*****
Vmux_2level_size50[36]->in[35] mux_2level_size50[36]->in[35] 0
+  0
***** Signal mux_2level_size50[36]->in[36] density = 0, probability=0.*****
Vmux_2level_size50[36]->in[36] mux_2level_size50[36]->in[36] 0
+  0
***** Signal mux_2level_size50[36]->in[37] density = 0, probability=0.*****
Vmux_2level_size50[36]->in[37] mux_2level_size50[36]->in[37] 0
+  0
***** Signal mux_2level_size50[36]->in[38] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[36]->in[38] mux_2level_size50[36]->in[38] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[36]->in[39] density = 0, probability=0.*****
Vmux_2level_size50[36]->in[39] mux_2level_size50[36]->in[39] 0
+  0
***** Signal mux_2level_size50[36]->in[40] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[36]->in[40] mux_2level_size50[36]->in[40] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[36]->in[41] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[36]->in[41] mux_2level_size50[36]->in[41] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[36]->in[42] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[36]->in[42] mux_2level_size50[36]->in[42] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[36]->in[43] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[36]->in[43] mux_2level_size50[36]->in[43] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[36]->in[44] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[36]->in[44] mux_2level_size50[36]->in[44] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[36]->in[45] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[36]->in[45] mux_2level_size50[36]->in[45] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[36]->in[46] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[36]->in[46] mux_2level_size50[36]->in[46] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[36]->in[47] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[36]->in[47] mux_2level_size50[36]->in[47] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[36]->in[48] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[36]->in[48] mux_2level_size50[36]->in[48] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[36]->in[49] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[36]->in[49] mux_2level_size50[36]->in[49] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
Vgvdd_mux_2level_size50[36] gvdd_mux_2level_size50[36] 0 vsp
***** Measurements *****
***** Rise delay *****
.meas tran delay_rise_idle_mux50[36]_in[0]_crossbar trig v(mux_2level_size50[36]->in[0]) val='input_thres_pct_rise*vsp' rise=1 td='clock_period'
+          targ v(mux_2level_size50[36]->out) val='output_thres_pct_rise*vsp' rise=1 td='clock_period'
***** Fall delay *****
.meas tran delay_fall_idle_mux50[36]_in[0]_crossbar trig v(mux_2level_size50[36]->in[0]) val='input_thres_pct_fall*vsp' fall=1 td='clock_period'
+          targ v(mux_2level_size50[36]->out) val='output_thres_pct_fall*vsp' fall=1 td='clock_period'
***** Rise timing period *****
.meas start_rise_idle_mux50[36]_in[0]_crossbar when v(mux_2level_size50[36]->in[0])='slew_lower_thres_pct_rise*vsp' rise=1 td='clock_period'
.meas tran switch_rise_idle_mux50[36]_in[0]_crossbar trig v(mux_2level_size50[36]->in[0]) val='slew_lower_thres_pct_rise*vsp' rise=1 td='clock_period'
+          targ v(mux_2level_size50[36]->out) val='slew_upper_thres_pct_rise*vsp' rise=1 td='clock_period'
***** Fall timing period *****
.meas start_fall_idle_mux50[36]_in[0]_crossbar when v(mux_2level_size50[36]->in[0])='slew_lower_thres_pct_fall*vsp' fall=1 td='clock_period'
.meas tran switch_fall_idle_mux50[36]_in[0]_crossbar trig v(mux_2level_size50[36]->in[0]) val='slew_lower_thres_pct_fall*vsp' fall=1 td='clock_period'
+          targ v(mux_2level_size50[36]->out) val='slew_upper_thres_pct_fall*vsp' fall=1 td='clock_period'
***** Leakage Power Measurement *****
.meas tran mux_2level_size50[36]_leakage_power avg p(Vgvdd_mux_2level_size50[36]) from=0 to='clock_period'
.meas tran leakage_idle_mux50[36]_in[0]_crossbar param='mux_2level_size50[36]_leakage_power'
***** Dynamic Power Measurement *****
.meas tran mux_2level_size50[36]_dynamic_power avg p(Vgvdd_mux_2level_size50[36]) from='clock_period' to='6*clock_period'
.meas tran mux_2level_size50[36]_energy_per_cycle param='mux_2level_size50[36]_dynamic_power*clock_period'
.meas tran dynamic_power_idle_mux50[36]_in[0]_crossbar  param='mux_2level_size50[36]_dynamic_power'
.meas tran energy_per_cycle_idle_mux50[36]_in[0]_crossbar  param='dynamic_power_idle_mux50[36]_in[0]_crossbar*clock_period'
.meas tran dynamic_rise_idle_mux50[36]_in[0]_crossbar avg p(Vgvdd_mux_2level_size50[36]) from='start_rise_idle_mux50[36]_in[0]_crossbar' to='start_rise_idle_mux50[36]_in[0]_crossbar+switch_rise_idle_mux50[36]_in[0]_crossbar'
.meas tran dynamic_fall_idle_mux50[36]_in[0]_crossbar avg p(Vgvdd_mux_2level_size50[36]) from='start_fall_idle_mux50[36]_in[0]_crossbar' to='start_fall_idle_mux50[36]_in[0]_crossbar+switch_fall_idle_mux50[36]_in[0]_crossbar'
.meas tran sum_leakage_power_mux[0to36]
+          param='sum_leakage_power_mux[0to35]+leakage_idle_mux50[36]_in[0]_crossbar'
.meas tran sum_energy_per_cycle_mux[0to36]
+          param='sum_energy_per_cycle_mux[0to35]+energy_per_cycle_idle_mux50[36]_in[0]_crossbar'
Xload_inv[36]_no0 mux_2level_size50[36]->out mux_2level_size50[36]->out_out[0] gvdd_load 0 inv size=5
.meas tran sum_leakage_power_pb_mux[0to36]
+          param='sum_leakage_power_pb_mux[0to35]+leakage_idle_mux50[36]_in[0]_crossbar'
.meas tran sum_energy_per_cycle_pb_mux[0to36]
+          param='sum_energy_per_cycle_pb_mux[0to35]+energy_per_cycle_idle_mux50[36]_in[0]_crossbar'
Xmux_2level_size50[37] mux_2level_size50[37]->in[0] mux_2level_size50[37]->in[1] mux_2level_size50[37]->in[2] mux_2level_size50[37]->in[3] mux_2level_size50[37]->in[4] mux_2level_size50[37]->in[5] mux_2level_size50[37]->in[6] mux_2level_size50[37]->in[7] mux_2level_size50[37]->in[8] mux_2level_size50[37]->in[9] mux_2level_size50[37]->in[10] mux_2level_size50[37]->in[11] mux_2level_size50[37]->in[12] mux_2level_size50[37]->in[13] mux_2level_size50[37]->in[14] mux_2level_size50[37]->in[15] mux_2level_size50[37]->in[16] mux_2level_size50[37]->in[17] mux_2level_size50[37]->in[18] mux_2level_size50[37]->in[19] mux_2level_size50[37]->in[20] mux_2level_size50[37]->in[21] mux_2level_size50[37]->in[22] mux_2level_size50[37]->in[23] mux_2level_size50[37]->in[24] mux_2level_size50[37]->in[25] mux_2level_size50[37]->in[26] mux_2level_size50[37]->in[27] mux_2level_size50[37]->in[28] mux_2level_size50[37]->in[29] mux_2level_size50[37]->in[30] mux_2level_size50[37]->in[31] mux_2level_size50[37]->in[32] mux_2level_size50[37]->in[33] mux_2level_size50[37]->in[34] mux_2level_size50[37]->in[35] mux_2level_size50[37]->in[36] mux_2level_size50[37]->in[37] mux_2level_size50[37]->in[38] mux_2level_size50[37]->in[39] mux_2level_size50[37]->in[40] mux_2level_size50[37]->in[41] mux_2level_size50[37]->in[42] mux_2level_size50[37]->in[43] mux_2level_size50[37]->in[44] mux_2level_size50[37]->in[45] mux_2level_size50[37]->in[46] mux_2level_size50[37]->in[47] mux_2level_size50[37]->in[48] mux_2level_size50[37]->in[49] mux_2level_size50[37]->out sram[592]->outb sram[592]->out sram[593]->out sram[593]->outb sram[594]->out sram[594]->outb sram[595]->out sram[595]->outb sram[596]->out sram[596]->outb sram[597]->out sram[597]->outb sram[598]->out sram[598]->outb sram[599]->out sram[599]->outb sram[600]->outb sram[600]->out sram[601]->out sram[601]->outb sram[602]->out sram[602]->outb sram[603]->out sram[603]->outb sram[604]->out sram[604]->outb sram[605]->out sram[605]->outb sram[606]->out sram[606]->outb sram[607]->out sram[607]->outb gvdd_mux_2level_size50[37] 0 mux_2level_size50
***** SRAM bits for MUX[37], level=2, select_path_id=0. *****
*****1000000010000000*****
Xsram[592] sram->in sram[592]->out sram[592]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[592]->out) 0
.nodeset V(sram[592]->outb) vsp
Xsram[593] sram->in sram[593]->out sram[593]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[593]->out) 0
.nodeset V(sram[593]->outb) vsp
Xsram[594] sram->in sram[594]->out sram[594]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[594]->out) 0
.nodeset V(sram[594]->outb) vsp
Xsram[595] sram->in sram[595]->out sram[595]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[595]->out) 0
.nodeset V(sram[595]->outb) vsp
Xsram[596] sram->in sram[596]->out sram[596]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[596]->out) 0
.nodeset V(sram[596]->outb) vsp
Xsram[597] sram->in sram[597]->out sram[597]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[597]->out) 0
.nodeset V(sram[597]->outb) vsp
Xsram[598] sram->in sram[598]->out sram[598]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[598]->out) 0
.nodeset V(sram[598]->outb) vsp
Xsram[599] sram->in sram[599]->out sram[599]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[599]->out) 0
.nodeset V(sram[599]->outb) vsp
Xsram[600] sram->in sram[600]->out sram[600]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[600]->out) 0
.nodeset V(sram[600]->outb) vsp
Xsram[601] sram->in sram[601]->out sram[601]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[601]->out) 0
.nodeset V(sram[601]->outb) vsp
Xsram[602] sram->in sram[602]->out sram[602]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[602]->out) 0
.nodeset V(sram[602]->outb) vsp
Xsram[603] sram->in sram[603]->out sram[603]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[603]->out) 0
.nodeset V(sram[603]->outb) vsp
Xsram[604] sram->in sram[604]->out sram[604]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[604]->out) 0
.nodeset V(sram[604]->outb) vsp
Xsram[605] sram->in sram[605]->out sram[605]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[605]->out) 0
.nodeset V(sram[605]->outb) vsp
Xsram[606] sram->in sram[606]->out sram[606]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[606]->out) 0
.nodeset V(sram[606]->outb) vsp
Xsram[607] sram->in sram[607]->out sram[607]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[607]->out) 0
.nodeset V(sram[607]->outb) vsp
***** Signal mux_2level_size50[37]->in[0] density = 0, probability=0.*****
Vmux_2level_size50[37]->in[0] mux_2level_size50[37]->in[0] 0
+  0
***** Signal mux_2level_size50[37]->in[1] density = 0, probability=0.*****
Vmux_2level_size50[37]->in[1] mux_2level_size50[37]->in[1] 0
+  0
***** Signal mux_2level_size50[37]->in[2] density = 0, probability=0.*****
Vmux_2level_size50[37]->in[2] mux_2level_size50[37]->in[2] 0
+  0
***** Signal mux_2level_size50[37]->in[3] density = 0, probability=0.*****
Vmux_2level_size50[37]->in[3] mux_2level_size50[37]->in[3] 0
+  0
***** Signal mux_2level_size50[37]->in[4] density = 0, probability=0.*****
Vmux_2level_size50[37]->in[4] mux_2level_size50[37]->in[4] 0
+  0
***** Signal mux_2level_size50[37]->in[5] density = 0, probability=0.*****
Vmux_2level_size50[37]->in[5] mux_2level_size50[37]->in[5] 0
+  0
***** Signal mux_2level_size50[37]->in[6] density = 0, probability=0.*****
Vmux_2level_size50[37]->in[6] mux_2level_size50[37]->in[6] 0
+  0
***** Signal mux_2level_size50[37]->in[7] density = 0, probability=0.*****
Vmux_2level_size50[37]->in[7] mux_2level_size50[37]->in[7] 0
+  0
***** Signal mux_2level_size50[37]->in[8] density = 0, probability=0.*****
Vmux_2level_size50[37]->in[8] mux_2level_size50[37]->in[8] 0
+  0
***** Signal mux_2level_size50[37]->in[9] density = 0, probability=0.*****
Vmux_2level_size50[37]->in[9] mux_2level_size50[37]->in[9] 0
+  0
***** Signal mux_2level_size50[37]->in[10] density = 0, probability=0.*****
Vmux_2level_size50[37]->in[10] mux_2level_size50[37]->in[10] 0
+  0
***** Signal mux_2level_size50[37]->in[11] density = 0, probability=0.*****
Vmux_2level_size50[37]->in[11] mux_2level_size50[37]->in[11] 0
+  0
***** Signal mux_2level_size50[37]->in[12] density = 0, probability=0.*****
Vmux_2level_size50[37]->in[12] mux_2level_size50[37]->in[12] 0
+  0
***** Signal mux_2level_size50[37]->in[13] density = 0, probability=0.*****
Vmux_2level_size50[37]->in[13] mux_2level_size50[37]->in[13] 0
+  0
***** Signal mux_2level_size50[37]->in[14] density = 0, probability=0.*****
Vmux_2level_size50[37]->in[14] mux_2level_size50[37]->in[14] 0
+  0
***** Signal mux_2level_size50[37]->in[15] density = 0, probability=0.*****
Vmux_2level_size50[37]->in[15] mux_2level_size50[37]->in[15] 0
+  0
***** Signal mux_2level_size50[37]->in[16] density = 0, probability=0.*****
Vmux_2level_size50[37]->in[16] mux_2level_size50[37]->in[16] 0
+  0
***** Signal mux_2level_size50[37]->in[17] density = 0, probability=0.*****
Vmux_2level_size50[37]->in[17] mux_2level_size50[37]->in[17] 0
+  0
***** Signal mux_2level_size50[37]->in[18] density = 0, probability=0.*****
Vmux_2level_size50[37]->in[18] mux_2level_size50[37]->in[18] 0
+  0
***** Signal mux_2level_size50[37]->in[19] density = 0, probability=0.*****
Vmux_2level_size50[37]->in[19] mux_2level_size50[37]->in[19] 0
+  0
***** Signal mux_2level_size50[37]->in[20] density = 0, probability=0.*****
Vmux_2level_size50[37]->in[20] mux_2level_size50[37]->in[20] 0
+  0
***** Signal mux_2level_size50[37]->in[21] density = 0, probability=0.*****
Vmux_2level_size50[37]->in[21] mux_2level_size50[37]->in[21] 0
+  0
***** Signal mux_2level_size50[37]->in[22] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[37]->in[22] mux_2level_size50[37]->in[22] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[37]->in[23] density = 0, probability=0.*****
Vmux_2level_size50[37]->in[23] mux_2level_size50[37]->in[23] 0
+  0
***** Signal mux_2level_size50[37]->in[24] density = 0, probability=0.*****
Vmux_2level_size50[37]->in[24] mux_2level_size50[37]->in[24] 0
+  0
***** Signal mux_2level_size50[37]->in[25] density = 0, probability=0.*****
Vmux_2level_size50[37]->in[25] mux_2level_size50[37]->in[25] 0
+  0
***** Signal mux_2level_size50[37]->in[26] density = 0, probability=0.*****
Vmux_2level_size50[37]->in[26] mux_2level_size50[37]->in[26] 0
+  0
***** Signal mux_2level_size50[37]->in[27] density = 0, probability=0.*****
Vmux_2level_size50[37]->in[27] mux_2level_size50[37]->in[27] 0
+  0
***** Signal mux_2level_size50[37]->in[28] density = 0, probability=0.*****
Vmux_2level_size50[37]->in[28] mux_2level_size50[37]->in[28] 0
+  0
***** Signal mux_2level_size50[37]->in[29] density = 0, probability=0.*****
Vmux_2level_size50[37]->in[29] mux_2level_size50[37]->in[29] 0
+  0
***** Signal mux_2level_size50[37]->in[30] density = 0, probability=0.*****
Vmux_2level_size50[37]->in[30] mux_2level_size50[37]->in[30] 0
+  0
***** Signal mux_2level_size50[37]->in[31] density = 0, probability=0.*****
Vmux_2level_size50[37]->in[31] mux_2level_size50[37]->in[31] 0
+  0
***** Signal mux_2level_size50[37]->in[32] density = 0, probability=0.*****
Vmux_2level_size50[37]->in[32] mux_2level_size50[37]->in[32] 0
+  0
***** Signal mux_2level_size50[37]->in[33] density = 0, probability=0.*****
Vmux_2level_size50[37]->in[33] mux_2level_size50[37]->in[33] 0
+  0
***** Signal mux_2level_size50[37]->in[34] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[37]->in[34] mux_2level_size50[37]->in[34] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[37]->in[35] density = 0, probability=0.*****
Vmux_2level_size50[37]->in[35] mux_2level_size50[37]->in[35] 0
+  0
***** Signal mux_2level_size50[37]->in[36] density = 0, probability=0.*****
Vmux_2level_size50[37]->in[36] mux_2level_size50[37]->in[36] 0
+  0
***** Signal mux_2level_size50[37]->in[37] density = 0, probability=0.*****
Vmux_2level_size50[37]->in[37] mux_2level_size50[37]->in[37] 0
+  0
***** Signal mux_2level_size50[37]->in[38] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[37]->in[38] mux_2level_size50[37]->in[38] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[37]->in[39] density = 0, probability=0.*****
Vmux_2level_size50[37]->in[39] mux_2level_size50[37]->in[39] 0
+  0
***** Signal mux_2level_size50[37]->in[40] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[37]->in[40] mux_2level_size50[37]->in[40] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[37]->in[41] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[37]->in[41] mux_2level_size50[37]->in[41] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[37]->in[42] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[37]->in[42] mux_2level_size50[37]->in[42] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[37]->in[43] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[37]->in[43] mux_2level_size50[37]->in[43] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[37]->in[44] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[37]->in[44] mux_2level_size50[37]->in[44] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[37]->in[45] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[37]->in[45] mux_2level_size50[37]->in[45] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[37]->in[46] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[37]->in[46] mux_2level_size50[37]->in[46] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[37]->in[47] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[37]->in[47] mux_2level_size50[37]->in[47] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[37]->in[48] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[37]->in[48] mux_2level_size50[37]->in[48] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[37]->in[49] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[37]->in[49] mux_2level_size50[37]->in[49] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
Vgvdd_mux_2level_size50[37] gvdd_mux_2level_size50[37] 0 vsp
***** Measurements *****
***** Rise delay *****
.meas tran delay_rise_idle_mux50[37]_in[1]_crossbar trig v(mux_2level_size50[37]->in[0]) val='input_thres_pct_rise*vsp' rise=1 td='clock_period'
+          targ v(mux_2level_size50[37]->out) val='output_thres_pct_rise*vsp' rise=1 td='clock_period'
***** Fall delay *****
.meas tran delay_fall_idle_mux50[37]_in[1]_crossbar trig v(mux_2level_size50[37]->in[0]) val='input_thres_pct_fall*vsp' fall=1 td='clock_period'
+          targ v(mux_2level_size50[37]->out) val='output_thres_pct_fall*vsp' fall=1 td='clock_period'
***** Rise timing period *****
.meas start_rise_idle_mux50[37]_in[1]_crossbar when v(mux_2level_size50[37]->in[0])='slew_lower_thres_pct_rise*vsp' rise=1 td='clock_period'
.meas tran switch_rise_idle_mux50[37]_in[1]_crossbar trig v(mux_2level_size50[37]->in[0]) val='slew_lower_thres_pct_rise*vsp' rise=1 td='clock_period'
+          targ v(mux_2level_size50[37]->out) val='slew_upper_thres_pct_rise*vsp' rise=1 td='clock_period'
***** Fall timing period *****
.meas start_fall_idle_mux50[37]_in[1]_crossbar when v(mux_2level_size50[37]->in[0])='slew_lower_thres_pct_fall*vsp' fall=1 td='clock_period'
.meas tran switch_fall_idle_mux50[37]_in[1]_crossbar trig v(mux_2level_size50[37]->in[0]) val='slew_lower_thres_pct_fall*vsp' fall=1 td='clock_period'
+          targ v(mux_2level_size50[37]->out) val='slew_upper_thres_pct_fall*vsp' fall=1 td='clock_period'
***** Leakage Power Measurement *****
.meas tran mux_2level_size50[37]_leakage_power avg p(Vgvdd_mux_2level_size50[37]) from=0 to='clock_period'
.meas tran leakage_idle_mux50[37]_in[1]_crossbar param='mux_2level_size50[37]_leakage_power'
***** Dynamic Power Measurement *****
.meas tran mux_2level_size50[37]_dynamic_power avg p(Vgvdd_mux_2level_size50[37]) from='clock_period' to='6*clock_period'
.meas tran mux_2level_size50[37]_energy_per_cycle param='mux_2level_size50[37]_dynamic_power*clock_period'
.meas tran dynamic_power_idle_mux50[37]_in[1]_crossbar  param='mux_2level_size50[37]_dynamic_power'
.meas tran energy_per_cycle_idle_mux50[37]_in[1]_crossbar  param='dynamic_power_idle_mux50[37]_in[1]_crossbar*clock_period'
.meas tran dynamic_rise_idle_mux50[37]_in[1]_crossbar avg p(Vgvdd_mux_2level_size50[37]) from='start_rise_idle_mux50[37]_in[1]_crossbar' to='start_rise_idle_mux50[37]_in[1]_crossbar+switch_rise_idle_mux50[37]_in[1]_crossbar'
.meas tran dynamic_fall_idle_mux50[37]_in[1]_crossbar avg p(Vgvdd_mux_2level_size50[37]) from='start_fall_idle_mux50[37]_in[1]_crossbar' to='start_fall_idle_mux50[37]_in[1]_crossbar+switch_fall_idle_mux50[37]_in[1]_crossbar'
.meas tran sum_leakage_power_mux[0to37]
+          param='sum_leakage_power_mux[0to36]+leakage_idle_mux50[37]_in[1]_crossbar'
.meas tran sum_energy_per_cycle_mux[0to37]
+          param='sum_energy_per_cycle_mux[0to36]+energy_per_cycle_idle_mux50[37]_in[1]_crossbar'
Xload_inv[37]_no0 mux_2level_size50[37]->out mux_2level_size50[37]->out_out[0] gvdd_load 0 inv size=5
.meas tran sum_leakage_power_pb_mux[0to37]
+          param='sum_leakage_power_pb_mux[0to36]+leakage_idle_mux50[37]_in[1]_crossbar'
.meas tran sum_energy_per_cycle_pb_mux[0to37]
+          param='sum_energy_per_cycle_pb_mux[0to36]+energy_per_cycle_idle_mux50[37]_in[1]_crossbar'
Xmux_2level_size50[38] mux_2level_size50[38]->in[0] mux_2level_size50[38]->in[1] mux_2level_size50[38]->in[2] mux_2level_size50[38]->in[3] mux_2level_size50[38]->in[4] mux_2level_size50[38]->in[5] mux_2level_size50[38]->in[6] mux_2level_size50[38]->in[7] mux_2level_size50[38]->in[8] mux_2level_size50[38]->in[9] mux_2level_size50[38]->in[10] mux_2level_size50[38]->in[11] mux_2level_size50[38]->in[12] mux_2level_size50[38]->in[13] mux_2level_size50[38]->in[14] mux_2level_size50[38]->in[15] mux_2level_size50[38]->in[16] mux_2level_size50[38]->in[17] mux_2level_size50[38]->in[18] mux_2level_size50[38]->in[19] mux_2level_size50[38]->in[20] mux_2level_size50[38]->in[21] mux_2level_size50[38]->in[22] mux_2level_size50[38]->in[23] mux_2level_size50[38]->in[24] mux_2level_size50[38]->in[25] mux_2level_size50[38]->in[26] mux_2level_size50[38]->in[27] mux_2level_size50[38]->in[28] mux_2level_size50[38]->in[29] mux_2level_size50[38]->in[30] mux_2level_size50[38]->in[31] mux_2level_size50[38]->in[32] mux_2level_size50[38]->in[33] mux_2level_size50[38]->in[34] mux_2level_size50[38]->in[35] mux_2level_size50[38]->in[36] mux_2level_size50[38]->in[37] mux_2level_size50[38]->in[38] mux_2level_size50[38]->in[39] mux_2level_size50[38]->in[40] mux_2level_size50[38]->in[41] mux_2level_size50[38]->in[42] mux_2level_size50[38]->in[43] mux_2level_size50[38]->in[44] mux_2level_size50[38]->in[45] mux_2level_size50[38]->in[46] mux_2level_size50[38]->in[47] mux_2level_size50[38]->in[48] mux_2level_size50[38]->in[49] mux_2level_size50[38]->out sram[608]->outb sram[608]->out sram[609]->out sram[609]->outb sram[610]->out sram[610]->outb sram[611]->out sram[611]->outb sram[612]->out sram[612]->outb sram[613]->out sram[613]->outb sram[614]->out sram[614]->outb sram[615]->out sram[615]->outb sram[616]->outb sram[616]->out sram[617]->out sram[617]->outb sram[618]->out sram[618]->outb sram[619]->out sram[619]->outb sram[620]->out sram[620]->outb sram[621]->out sram[621]->outb sram[622]->out sram[622]->outb sram[623]->out sram[623]->outb gvdd_mux_2level_size50[38] 0 mux_2level_size50
***** SRAM bits for MUX[38], level=2, select_path_id=0. *****
*****1000000010000000*****
Xsram[608] sram->in sram[608]->out sram[608]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[608]->out) 0
.nodeset V(sram[608]->outb) vsp
Xsram[609] sram->in sram[609]->out sram[609]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[609]->out) 0
.nodeset V(sram[609]->outb) vsp
Xsram[610] sram->in sram[610]->out sram[610]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[610]->out) 0
.nodeset V(sram[610]->outb) vsp
Xsram[611] sram->in sram[611]->out sram[611]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[611]->out) 0
.nodeset V(sram[611]->outb) vsp
Xsram[612] sram->in sram[612]->out sram[612]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[612]->out) 0
.nodeset V(sram[612]->outb) vsp
Xsram[613] sram->in sram[613]->out sram[613]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[613]->out) 0
.nodeset V(sram[613]->outb) vsp
Xsram[614] sram->in sram[614]->out sram[614]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[614]->out) 0
.nodeset V(sram[614]->outb) vsp
Xsram[615] sram->in sram[615]->out sram[615]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[615]->out) 0
.nodeset V(sram[615]->outb) vsp
Xsram[616] sram->in sram[616]->out sram[616]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[616]->out) 0
.nodeset V(sram[616]->outb) vsp
Xsram[617] sram->in sram[617]->out sram[617]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[617]->out) 0
.nodeset V(sram[617]->outb) vsp
Xsram[618] sram->in sram[618]->out sram[618]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[618]->out) 0
.nodeset V(sram[618]->outb) vsp
Xsram[619] sram->in sram[619]->out sram[619]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[619]->out) 0
.nodeset V(sram[619]->outb) vsp
Xsram[620] sram->in sram[620]->out sram[620]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[620]->out) 0
.nodeset V(sram[620]->outb) vsp
Xsram[621] sram->in sram[621]->out sram[621]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[621]->out) 0
.nodeset V(sram[621]->outb) vsp
Xsram[622] sram->in sram[622]->out sram[622]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[622]->out) 0
.nodeset V(sram[622]->outb) vsp
Xsram[623] sram->in sram[623]->out sram[623]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[623]->out) 0
.nodeset V(sram[623]->outb) vsp
***** Signal mux_2level_size50[38]->in[0] density = 0, probability=0.*****
Vmux_2level_size50[38]->in[0] mux_2level_size50[38]->in[0] 0
+  0
***** Signal mux_2level_size50[38]->in[1] density = 0, probability=0.*****
Vmux_2level_size50[38]->in[1] mux_2level_size50[38]->in[1] 0
+  0
***** Signal mux_2level_size50[38]->in[2] density = 0, probability=0.*****
Vmux_2level_size50[38]->in[2] mux_2level_size50[38]->in[2] 0
+  0
***** Signal mux_2level_size50[38]->in[3] density = 0, probability=0.*****
Vmux_2level_size50[38]->in[3] mux_2level_size50[38]->in[3] 0
+  0
***** Signal mux_2level_size50[38]->in[4] density = 0, probability=0.*****
Vmux_2level_size50[38]->in[4] mux_2level_size50[38]->in[4] 0
+  0
***** Signal mux_2level_size50[38]->in[5] density = 0, probability=0.*****
Vmux_2level_size50[38]->in[5] mux_2level_size50[38]->in[5] 0
+  0
***** Signal mux_2level_size50[38]->in[6] density = 0, probability=0.*****
Vmux_2level_size50[38]->in[6] mux_2level_size50[38]->in[6] 0
+  0
***** Signal mux_2level_size50[38]->in[7] density = 0, probability=0.*****
Vmux_2level_size50[38]->in[7] mux_2level_size50[38]->in[7] 0
+  0
***** Signal mux_2level_size50[38]->in[8] density = 0, probability=0.*****
Vmux_2level_size50[38]->in[8] mux_2level_size50[38]->in[8] 0
+  0
***** Signal mux_2level_size50[38]->in[9] density = 0, probability=0.*****
Vmux_2level_size50[38]->in[9] mux_2level_size50[38]->in[9] 0
+  0
***** Signal mux_2level_size50[38]->in[10] density = 0, probability=0.*****
Vmux_2level_size50[38]->in[10] mux_2level_size50[38]->in[10] 0
+  0
***** Signal mux_2level_size50[38]->in[11] density = 0, probability=0.*****
Vmux_2level_size50[38]->in[11] mux_2level_size50[38]->in[11] 0
+  0
***** Signal mux_2level_size50[38]->in[12] density = 0, probability=0.*****
Vmux_2level_size50[38]->in[12] mux_2level_size50[38]->in[12] 0
+  0
***** Signal mux_2level_size50[38]->in[13] density = 0, probability=0.*****
Vmux_2level_size50[38]->in[13] mux_2level_size50[38]->in[13] 0
+  0
***** Signal mux_2level_size50[38]->in[14] density = 0, probability=0.*****
Vmux_2level_size50[38]->in[14] mux_2level_size50[38]->in[14] 0
+  0
***** Signal mux_2level_size50[38]->in[15] density = 0, probability=0.*****
Vmux_2level_size50[38]->in[15] mux_2level_size50[38]->in[15] 0
+  0
***** Signal mux_2level_size50[38]->in[16] density = 0, probability=0.*****
Vmux_2level_size50[38]->in[16] mux_2level_size50[38]->in[16] 0
+  0
***** Signal mux_2level_size50[38]->in[17] density = 0, probability=0.*****
Vmux_2level_size50[38]->in[17] mux_2level_size50[38]->in[17] 0
+  0
***** Signal mux_2level_size50[38]->in[18] density = 0, probability=0.*****
Vmux_2level_size50[38]->in[18] mux_2level_size50[38]->in[18] 0
+  0
***** Signal mux_2level_size50[38]->in[19] density = 0, probability=0.*****
Vmux_2level_size50[38]->in[19] mux_2level_size50[38]->in[19] 0
+  0
***** Signal mux_2level_size50[38]->in[20] density = 0, probability=0.*****
Vmux_2level_size50[38]->in[20] mux_2level_size50[38]->in[20] 0
+  0
***** Signal mux_2level_size50[38]->in[21] density = 0, probability=0.*****
Vmux_2level_size50[38]->in[21] mux_2level_size50[38]->in[21] 0
+  0
***** Signal mux_2level_size50[38]->in[22] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[38]->in[22] mux_2level_size50[38]->in[22] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[38]->in[23] density = 0, probability=0.*****
Vmux_2level_size50[38]->in[23] mux_2level_size50[38]->in[23] 0
+  0
***** Signal mux_2level_size50[38]->in[24] density = 0, probability=0.*****
Vmux_2level_size50[38]->in[24] mux_2level_size50[38]->in[24] 0
+  0
***** Signal mux_2level_size50[38]->in[25] density = 0, probability=0.*****
Vmux_2level_size50[38]->in[25] mux_2level_size50[38]->in[25] 0
+  0
***** Signal mux_2level_size50[38]->in[26] density = 0, probability=0.*****
Vmux_2level_size50[38]->in[26] mux_2level_size50[38]->in[26] 0
+  0
***** Signal mux_2level_size50[38]->in[27] density = 0, probability=0.*****
Vmux_2level_size50[38]->in[27] mux_2level_size50[38]->in[27] 0
+  0
***** Signal mux_2level_size50[38]->in[28] density = 0, probability=0.*****
Vmux_2level_size50[38]->in[28] mux_2level_size50[38]->in[28] 0
+  0
***** Signal mux_2level_size50[38]->in[29] density = 0, probability=0.*****
Vmux_2level_size50[38]->in[29] mux_2level_size50[38]->in[29] 0
+  0
***** Signal mux_2level_size50[38]->in[30] density = 0, probability=0.*****
Vmux_2level_size50[38]->in[30] mux_2level_size50[38]->in[30] 0
+  0
***** Signal mux_2level_size50[38]->in[31] density = 0, probability=0.*****
Vmux_2level_size50[38]->in[31] mux_2level_size50[38]->in[31] 0
+  0
***** Signal mux_2level_size50[38]->in[32] density = 0, probability=0.*****
Vmux_2level_size50[38]->in[32] mux_2level_size50[38]->in[32] 0
+  0
***** Signal mux_2level_size50[38]->in[33] density = 0, probability=0.*****
Vmux_2level_size50[38]->in[33] mux_2level_size50[38]->in[33] 0
+  0
***** Signal mux_2level_size50[38]->in[34] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[38]->in[34] mux_2level_size50[38]->in[34] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[38]->in[35] density = 0, probability=0.*****
Vmux_2level_size50[38]->in[35] mux_2level_size50[38]->in[35] 0
+  0
***** Signal mux_2level_size50[38]->in[36] density = 0, probability=0.*****
Vmux_2level_size50[38]->in[36] mux_2level_size50[38]->in[36] 0
+  0
***** Signal mux_2level_size50[38]->in[37] density = 0, probability=0.*****
Vmux_2level_size50[38]->in[37] mux_2level_size50[38]->in[37] 0
+  0
***** Signal mux_2level_size50[38]->in[38] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[38]->in[38] mux_2level_size50[38]->in[38] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[38]->in[39] density = 0, probability=0.*****
Vmux_2level_size50[38]->in[39] mux_2level_size50[38]->in[39] 0
+  0
***** Signal mux_2level_size50[38]->in[40] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[38]->in[40] mux_2level_size50[38]->in[40] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[38]->in[41] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[38]->in[41] mux_2level_size50[38]->in[41] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[38]->in[42] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[38]->in[42] mux_2level_size50[38]->in[42] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[38]->in[43] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[38]->in[43] mux_2level_size50[38]->in[43] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[38]->in[44] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[38]->in[44] mux_2level_size50[38]->in[44] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[38]->in[45] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[38]->in[45] mux_2level_size50[38]->in[45] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[38]->in[46] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[38]->in[46] mux_2level_size50[38]->in[46] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[38]->in[47] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[38]->in[47] mux_2level_size50[38]->in[47] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[38]->in[48] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[38]->in[48] mux_2level_size50[38]->in[48] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[38]->in[49] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[38]->in[49] mux_2level_size50[38]->in[49] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
Vgvdd_mux_2level_size50[38] gvdd_mux_2level_size50[38] 0 vsp
***** Measurements *****
***** Rise delay *****
.meas tran delay_rise_idle_mux50[38]_in[2]_crossbar trig v(mux_2level_size50[38]->in[0]) val='input_thres_pct_rise*vsp' rise=1 td='clock_period'
+          targ v(mux_2level_size50[38]->out) val='output_thres_pct_rise*vsp' rise=1 td='clock_period'
***** Fall delay *****
.meas tran delay_fall_idle_mux50[38]_in[2]_crossbar trig v(mux_2level_size50[38]->in[0]) val='input_thres_pct_fall*vsp' fall=1 td='clock_period'
+          targ v(mux_2level_size50[38]->out) val='output_thres_pct_fall*vsp' fall=1 td='clock_period'
***** Rise timing period *****
.meas start_rise_idle_mux50[38]_in[2]_crossbar when v(mux_2level_size50[38]->in[0])='slew_lower_thres_pct_rise*vsp' rise=1 td='clock_period'
.meas tran switch_rise_idle_mux50[38]_in[2]_crossbar trig v(mux_2level_size50[38]->in[0]) val='slew_lower_thres_pct_rise*vsp' rise=1 td='clock_period'
+          targ v(mux_2level_size50[38]->out) val='slew_upper_thres_pct_rise*vsp' rise=1 td='clock_period'
***** Fall timing period *****
.meas start_fall_idle_mux50[38]_in[2]_crossbar when v(mux_2level_size50[38]->in[0])='slew_lower_thres_pct_fall*vsp' fall=1 td='clock_period'
.meas tran switch_fall_idle_mux50[38]_in[2]_crossbar trig v(mux_2level_size50[38]->in[0]) val='slew_lower_thres_pct_fall*vsp' fall=1 td='clock_period'
+          targ v(mux_2level_size50[38]->out) val='slew_upper_thres_pct_fall*vsp' fall=1 td='clock_period'
***** Leakage Power Measurement *****
.meas tran mux_2level_size50[38]_leakage_power avg p(Vgvdd_mux_2level_size50[38]) from=0 to='clock_period'
.meas tran leakage_idle_mux50[38]_in[2]_crossbar param='mux_2level_size50[38]_leakage_power'
***** Dynamic Power Measurement *****
.meas tran mux_2level_size50[38]_dynamic_power avg p(Vgvdd_mux_2level_size50[38]) from='clock_period' to='6*clock_period'
.meas tran mux_2level_size50[38]_energy_per_cycle param='mux_2level_size50[38]_dynamic_power*clock_period'
.meas tran dynamic_power_idle_mux50[38]_in[2]_crossbar  param='mux_2level_size50[38]_dynamic_power'
.meas tran energy_per_cycle_idle_mux50[38]_in[2]_crossbar  param='dynamic_power_idle_mux50[38]_in[2]_crossbar*clock_period'
.meas tran dynamic_rise_idle_mux50[38]_in[2]_crossbar avg p(Vgvdd_mux_2level_size50[38]) from='start_rise_idle_mux50[38]_in[2]_crossbar' to='start_rise_idle_mux50[38]_in[2]_crossbar+switch_rise_idle_mux50[38]_in[2]_crossbar'
.meas tran dynamic_fall_idle_mux50[38]_in[2]_crossbar avg p(Vgvdd_mux_2level_size50[38]) from='start_fall_idle_mux50[38]_in[2]_crossbar' to='start_fall_idle_mux50[38]_in[2]_crossbar+switch_fall_idle_mux50[38]_in[2]_crossbar'
.meas tran sum_leakage_power_mux[0to38]
+          param='sum_leakage_power_mux[0to37]+leakage_idle_mux50[38]_in[2]_crossbar'
.meas tran sum_energy_per_cycle_mux[0to38]
+          param='sum_energy_per_cycle_mux[0to37]+energy_per_cycle_idle_mux50[38]_in[2]_crossbar'
Xload_inv[38]_no0 mux_2level_size50[38]->out mux_2level_size50[38]->out_out[0] gvdd_load 0 inv size=5
.meas tran sum_leakage_power_pb_mux[0to38]
+          param='sum_leakage_power_pb_mux[0to37]+leakage_idle_mux50[38]_in[2]_crossbar'
.meas tran sum_energy_per_cycle_pb_mux[0to38]
+          param='sum_energy_per_cycle_pb_mux[0to37]+energy_per_cycle_idle_mux50[38]_in[2]_crossbar'
Xmux_2level_size50[39] mux_2level_size50[39]->in[0] mux_2level_size50[39]->in[1] mux_2level_size50[39]->in[2] mux_2level_size50[39]->in[3] mux_2level_size50[39]->in[4] mux_2level_size50[39]->in[5] mux_2level_size50[39]->in[6] mux_2level_size50[39]->in[7] mux_2level_size50[39]->in[8] mux_2level_size50[39]->in[9] mux_2level_size50[39]->in[10] mux_2level_size50[39]->in[11] mux_2level_size50[39]->in[12] mux_2level_size50[39]->in[13] mux_2level_size50[39]->in[14] mux_2level_size50[39]->in[15] mux_2level_size50[39]->in[16] mux_2level_size50[39]->in[17] mux_2level_size50[39]->in[18] mux_2level_size50[39]->in[19] mux_2level_size50[39]->in[20] mux_2level_size50[39]->in[21] mux_2level_size50[39]->in[22] mux_2level_size50[39]->in[23] mux_2level_size50[39]->in[24] mux_2level_size50[39]->in[25] mux_2level_size50[39]->in[26] mux_2level_size50[39]->in[27] mux_2level_size50[39]->in[28] mux_2level_size50[39]->in[29] mux_2level_size50[39]->in[30] mux_2level_size50[39]->in[31] mux_2level_size50[39]->in[32] mux_2level_size50[39]->in[33] mux_2level_size50[39]->in[34] mux_2level_size50[39]->in[35] mux_2level_size50[39]->in[36] mux_2level_size50[39]->in[37] mux_2level_size50[39]->in[38] mux_2level_size50[39]->in[39] mux_2level_size50[39]->in[40] mux_2level_size50[39]->in[41] mux_2level_size50[39]->in[42] mux_2level_size50[39]->in[43] mux_2level_size50[39]->in[44] mux_2level_size50[39]->in[45] mux_2level_size50[39]->in[46] mux_2level_size50[39]->in[47] mux_2level_size50[39]->in[48] mux_2level_size50[39]->in[49] mux_2level_size50[39]->out sram[624]->outb sram[624]->out sram[625]->out sram[625]->outb sram[626]->out sram[626]->outb sram[627]->out sram[627]->outb sram[628]->out sram[628]->outb sram[629]->out sram[629]->outb sram[630]->out sram[630]->outb sram[631]->out sram[631]->outb sram[632]->outb sram[632]->out sram[633]->out sram[633]->outb sram[634]->out sram[634]->outb sram[635]->out sram[635]->outb sram[636]->out sram[636]->outb sram[637]->out sram[637]->outb sram[638]->out sram[638]->outb sram[639]->out sram[639]->outb gvdd_mux_2level_size50[39] 0 mux_2level_size50
***** SRAM bits for MUX[39], level=2, select_path_id=0. *****
*****1000000010000000*****
Xsram[624] sram->in sram[624]->out sram[624]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[624]->out) 0
.nodeset V(sram[624]->outb) vsp
Xsram[625] sram->in sram[625]->out sram[625]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[625]->out) 0
.nodeset V(sram[625]->outb) vsp
Xsram[626] sram->in sram[626]->out sram[626]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[626]->out) 0
.nodeset V(sram[626]->outb) vsp
Xsram[627] sram->in sram[627]->out sram[627]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[627]->out) 0
.nodeset V(sram[627]->outb) vsp
Xsram[628] sram->in sram[628]->out sram[628]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[628]->out) 0
.nodeset V(sram[628]->outb) vsp
Xsram[629] sram->in sram[629]->out sram[629]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[629]->out) 0
.nodeset V(sram[629]->outb) vsp
Xsram[630] sram->in sram[630]->out sram[630]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[630]->out) 0
.nodeset V(sram[630]->outb) vsp
Xsram[631] sram->in sram[631]->out sram[631]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[631]->out) 0
.nodeset V(sram[631]->outb) vsp
Xsram[632] sram->in sram[632]->out sram[632]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[632]->out) 0
.nodeset V(sram[632]->outb) vsp
Xsram[633] sram->in sram[633]->out sram[633]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[633]->out) 0
.nodeset V(sram[633]->outb) vsp
Xsram[634] sram->in sram[634]->out sram[634]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[634]->out) 0
.nodeset V(sram[634]->outb) vsp
Xsram[635] sram->in sram[635]->out sram[635]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[635]->out) 0
.nodeset V(sram[635]->outb) vsp
Xsram[636] sram->in sram[636]->out sram[636]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[636]->out) 0
.nodeset V(sram[636]->outb) vsp
Xsram[637] sram->in sram[637]->out sram[637]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[637]->out) 0
.nodeset V(sram[637]->outb) vsp
Xsram[638] sram->in sram[638]->out sram[638]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[638]->out) 0
.nodeset V(sram[638]->outb) vsp
Xsram[639] sram->in sram[639]->out sram[639]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[639]->out) 0
.nodeset V(sram[639]->outb) vsp
***** Signal mux_2level_size50[39]->in[0] density = 0, probability=0.*****
Vmux_2level_size50[39]->in[0] mux_2level_size50[39]->in[0] 0
+  0
***** Signal mux_2level_size50[39]->in[1] density = 0, probability=0.*****
Vmux_2level_size50[39]->in[1] mux_2level_size50[39]->in[1] 0
+  0
***** Signal mux_2level_size50[39]->in[2] density = 0, probability=0.*****
Vmux_2level_size50[39]->in[2] mux_2level_size50[39]->in[2] 0
+  0
***** Signal mux_2level_size50[39]->in[3] density = 0, probability=0.*****
Vmux_2level_size50[39]->in[3] mux_2level_size50[39]->in[3] 0
+  0
***** Signal mux_2level_size50[39]->in[4] density = 0, probability=0.*****
Vmux_2level_size50[39]->in[4] mux_2level_size50[39]->in[4] 0
+  0
***** Signal mux_2level_size50[39]->in[5] density = 0, probability=0.*****
Vmux_2level_size50[39]->in[5] mux_2level_size50[39]->in[5] 0
+  0
***** Signal mux_2level_size50[39]->in[6] density = 0, probability=0.*****
Vmux_2level_size50[39]->in[6] mux_2level_size50[39]->in[6] 0
+  0
***** Signal mux_2level_size50[39]->in[7] density = 0, probability=0.*****
Vmux_2level_size50[39]->in[7] mux_2level_size50[39]->in[7] 0
+  0
***** Signal mux_2level_size50[39]->in[8] density = 0, probability=0.*****
Vmux_2level_size50[39]->in[8] mux_2level_size50[39]->in[8] 0
+  0
***** Signal mux_2level_size50[39]->in[9] density = 0, probability=0.*****
Vmux_2level_size50[39]->in[9] mux_2level_size50[39]->in[9] 0
+  0
***** Signal mux_2level_size50[39]->in[10] density = 0, probability=0.*****
Vmux_2level_size50[39]->in[10] mux_2level_size50[39]->in[10] 0
+  0
***** Signal mux_2level_size50[39]->in[11] density = 0, probability=0.*****
Vmux_2level_size50[39]->in[11] mux_2level_size50[39]->in[11] 0
+  0
***** Signal mux_2level_size50[39]->in[12] density = 0, probability=0.*****
Vmux_2level_size50[39]->in[12] mux_2level_size50[39]->in[12] 0
+  0
***** Signal mux_2level_size50[39]->in[13] density = 0, probability=0.*****
Vmux_2level_size50[39]->in[13] mux_2level_size50[39]->in[13] 0
+  0
***** Signal mux_2level_size50[39]->in[14] density = 0, probability=0.*****
Vmux_2level_size50[39]->in[14] mux_2level_size50[39]->in[14] 0
+  0
***** Signal mux_2level_size50[39]->in[15] density = 0, probability=0.*****
Vmux_2level_size50[39]->in[15] mux_2level_size50[39]->in[15] 0
+  0
***** Signal mux_2level_size50[39]->in[16] density = 0, probability=0.*****
Vmux_2level_size50[39]->in[16] mux_2level_size50[39]->in[16] 0
+  0
***** Signal mux_2level_size50[39]->in[17] density = 0, probability=0.*****
Vmux_2level_size50[39]->in[17] mux_2level_size50[39]->in[17] 0
+  0
***** Signal mux_2level_size50[39]->in[18] density = 0, probability=0.*****
Vmux_2level_size50[39]->in[18] mux_2level_size50[39]->in[18] 0
+  0
***** Signal mux_2level_size50[39]->in[19] density = 0, probability=0.*****
Vmux_2level_size50[39]->in[19] mux_2level_size50[39]->in[19] 0
+  0
***** Signal mux_2level_size50[39]->in[20] density = 0, probability=0.*****
Vmux_2level_size50[39]->in[20] mux_2level_size50[39]->in[20] 0
+  0
***** Signal mux_2level_size50[39]->in[21] density = 0, probability=0.*****
Vmux_2level_size50[39]->in[21] mux_2level_size50[39]->in[21] 0
+  0
***** Signal mux_2level_size50[39]->in[22] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[39]->in[22] mux_2level_size50[39]->in[22] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[39]->in[23] density = 0, probability=0.*****
Vmux_2level_size50[39]->in[23] mux_2level_size50[39]->in[23] 0
+  0
***** Signal mux_2level_size50[39]->in[24] density = 0, probability=0.*****
Vmux_2level_size50[39]->in[24] mux_2level_size50[39]->in[24] 0
+  0
***** Signal mux_2level_size50[39]->in[25] density = 0, probability=0.*****
Vmux_2level_size50[39]->in[25] mux_2level_size50[39]->in[25] 0
+  0
***** Signal mux_2level_size50[39]->in[26] density = 0, probability=0.*****
Vmux_2level_size50[39]->in[26] mux_2level_size50[39]->in[26] 0
+  0
***** Signal mux_2level_size50[39]->in[27] density = 0, probability=0.*****
Vmux_2level_size50[39]->in[27] mux_2level_size50[39]->in[27] 0
+  0
***** Signal mux_2level_size50[39]->in[28] density = 0, probability=0.*****
Vmux_2level_size50[39]->in[28] mux_2level_size50[39]->in[28] 0
+  0
***** Signal mux_2level_size50[39]->in[29] density = 0, probability=0.*****
Vmux_2level_size50[39]->in[29] mux_2level_size50[39]->in[29] 0
+  0
***** Signal mux_2level_size50[39]->in[30] density = 0, probability=0.*****
Vmux_2level_size50[39]->in[30] mux_2level_size50[39]->in[30] 0
+  0
***** Signal mux_2level_size50[39]->in[31] density = 0, probability=0.*****
Vmux_2level_size50[39]->in[31] mux_2level_size50[39]->in[31] 0
+  0
***** Signal mux_2level_size50[39]->in[32] density = 0, probability=0.*****
Vmux_2level_size50[39]->in[32] mux_2level_size50[39]->in[32] 0
+  0
***** Signal mux_2level_size50[39]->in[33] density = 0, probability=0.*****
Vmux_2level_size50[39]->in[33] mux_2level_size50[39]->in[33] 0
+  0
***** Signal mux_2level_size50[39]->in[34] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[39]->in[34] mux_2level_size50[39]->in[34] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[39]->in[35] density = 0, probability=0.*****
Vmux_2level_size50[39]->in[35] mux_2level_size50[39]->in[35] 0
+  0
***** Signal mux_2level_size50[39]->in[36] density = 0, probability=0.*****
Vmux_2level_size50[39]->in[36] mux_2level_size50[39]->in[36] 0
+  0
***** Signal mux_2level_size50[39]->in[37] density = 0, probability=0.*****
Vmux_2level_size50[39]->in[37] mux_2level_size50[39]->in[37] 0
+  0
***** Signal mux_2level_size50[39]->in[38] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[39]->in[38] mux_2level_size50[39]->in[38] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[39]->in[39] density = 0, probability=0.*****
Vmux_2level_size50[39]->in[39] mux_2level_size50[39]->in[39] 0
+  0
***** Signal mux_2level_size50[39]->in[40] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[39]->in[40] mux_2level_size50[39]->in[40] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[39]->in[41] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[39]->in[41] mux_2level_size50[39]->in[41] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[39]->in[42] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[39]->in[42] mux_2level_size50[39]->in[42] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[39]->in[43] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[39]->in[43] mux_2level_size50[39]->in[43] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[39]->in[44] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[39]->in[44] mux_2level_size50[39]->in[44] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[39]->in[45] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[39]->in[45] mux_2level_size50[39]->in[45] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[39]->in[46] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[39]->in[46] mux_2level_size50[39]->in[46] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[39]->in[47] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[39]->in[47] mux_2level_size50[39]->in[47] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[39]->in[48] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[39]->in[48] mux_2level_size50[39]->in[48] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[39]->in[49] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[39]->in[49] mux_2level_size50[39]->in[49] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
Vgvdd_mux_2level_size50[39] gvdd_mux_2level_size50[39] 0 vsp
***** Measurements *****
***** Rise delay *****
.meas tran delay_rise_idle_mux50[39]_in[3]_crossbar trig v(mux_2level_size50[39]->in[0]) val='input_thres_pct_rise*vsp' rise=1 td='clock_period'
+          targ v(mux_2level_size50[39]->out) val='output_thres_pct_rise*vsp' rise=1 td='clock_period'
***** Fall delay *****
.meas tran delay_fall_idle_mux50[39]_in[3]_crossbar trig v(mux_2level_size50[39]->in[0]) val='input_thres_pct_fall*vsp' fall=1 td='clock_period'
+          targ v(mux_2level_size50[39]->out) val='output_thres_pct_fall*vsp' fall=1 td='clock_period'
***** Rise timing period *****
.meas start_rise_idle_mux50[39]_in[3]_crossbar when v(mux_2level_size50[39]->in[0])='slew_lower_thres_pct_rise*vsp' rise=1 td='clock_period'
.meas tran switch_rise_idle_mux50[39]_in[3]_crossbar trig v(mux_2level_size50[39]->in[0]) val='slew_lower_thres_pct_rise*vsp' rise=1 td='clock_period'
+          targ v(mux_2level_size50[39]->out) val='slew_upper_thres_pct_rise*vsp' rise=1 td='clock_period'
***** Fall timing period *****
.meas start_fall_idle_mux50[39]_in[3]_crossbar when v(mux_2level_size50[39]->in[0])='slew_lower_thres_pct_fall*vsp' fall=1 td='clock_period'
.meas tran switch_fall_idle_mux50[39]_in[3]_crossbar trig v(mux_2level_size50[39]->in[0]) val='slew_lower_thres_pct_fall*vsp' fall=1 td='clock_period'
+          targ v(mux_2level_size50[39]->out) val='slew_upper_thres_pct_fall*vsp' fall=1 td='clock_period'
***** Leakage Power Measurement *****
.meas tran mux_2level_size50[39]_leakage_power avg p(Vgvdd_mux_2level_size50[39]) from=0 to='clock_period'
.meas tran leakage_idle_mux50[39]_in[3]_crossbar param='mux_2level_size50[39]_leakage_power'
***** Dynamic Power Measurement *****
.meas tran mux_2level_size50[39]_dynamic_power avg p(Vgvdd_mux_2level_size50[39]) from='clock_period' to='6*clock_period'
.meas tran mux_2level_size50[39]_energy_per_cycle param='mux_2level_size50[39]_dynamic_power*clock_period'
.meas tran dynamic_power_idle_mux50[39]_in[3]_crossbar  param='mux_2level_size50[39]_dynamic_power'
.meas tran energy_per_cycle_idle_mux50[39]_in[3]_crossbar  param='dynamic_power_idle_mux50[39]_in[3]_crossbar*clock_period'
.meas tran dynamic_rise_idle_mux50[39]_in[3]_crossbar avg p(Vgvdd_mux_2level_size50[39]) from='start_rise_idle_mux50[39]_in[3]_crossbar' to='start_rise_idle_mux50[39]_in[3]_crossbar+switch_rise_idle_mux50[39]_in[3]_crossbar'
.meas tran dynamic_fall_idle_mux50[39]_in[3]_crossbar avg p(Vgvdd_mux_2level_size50[39]) from='start_fall_idle_mux50[39]_in[3]_crossbar' to='start_fall_idle_mux50[39]_in[3]_crossbar+switch_fall_idle_mux50[39]_in[3]_crossbar'
.meas tran sum_leakage_power_mux[0to39]
+          param='sum_leakage_power_mux[0to38]+leakage_idle_mux50[39]_in[3]_crossbar'
.meas tran sum_energy_per_cycle_mux[0to39]
+          param='sum_energy_per_cycle_mux[0to38]+energy_per_cycle_idle_mux50[39]_in[3]_crossbar'
Xload_inv[39]_no0 mux_2level_size50[39]->out mux_2level_size50[39]->out_out[0] gvdd_load 0 inv size=5
.meas tran sum_leakage_power_pb_mux[0to39]
+          param='sum_leakage_power_pb_mux[0to38]+leakage_idle_mux50[39]_in[3]_crossbar'
.meas tran sum_energy_per_cycle_pb_mux[0to39]
+          param='sum_energy_per_cycle_pb_mux[0to38]+energy_per_cycle_idle_mux50[39]_in[3]_crossbar'
Xmux_2level_size50[40] mux_2level_size50[40]->in[0] mux_2level_size50[40]->in[1] mux_2level_size50[40]->in[2] mux_2level_size50[40]->in[3] mux_2level_size50[40]->in[4] mux_2level_size50[40]->in[5] mux_2level_size50[40]->in[6] mux_2level_size50[40]->in[7] mux_2level_size50[40]->in[8] mux_2level_size50[40]->in[9] mux_2level_size50[40]->in[10] mux_2level_size50[40]->in[11] mux_2level_size50[40]->in[12] mux_2level_size50[40]->in[13] mux_2level_size50[40]->in[14] mux_2level_size50[40]->in[15] mux_2level_size50[40]->in[16] mux_2level_size50[40]->in[17] mux_2level_size50[40]->in[18] mux_2level_size50[40]->in[19] mux_2level_size50[40]->in[20] mux_2level_size50[40]->in[21] mux_2level_size50[40]->in[22] mux_2level_size50[40]->in[23] mux_2level_size50[40]->in[24] mux_2level_size50[40]->in[25] mux_2level_size50[40]->in[26] mux_2level_size50[40]->in[27] mux_2level_size50[40]->in[28] mux_2level_size50[40]->in[29] mux_2level_size50[40]->in[30] mux_2level_size50[40]->in[31] mux_2level_size50[40]->in[32] mux_2level_size50[40]->in[33] mux_2level_size50[40]->in[34] mux_2level_size50[40]->in[35] mux_2level_size50[40]->in[36] mux_2level_size50[40]->in[37] mux_2level_size50[40]->in[38] mux_2level_size50[40]->in[39] mux_2level_size50[40]->in[40] mux_2level_size50[40]->in[41] mux_2level_size50[40]->in[42] mux_2level_size50[40]->in[43] mux_2level_size50[40]->in[44] mux_2level_size50[40]->in[45] mux_2level_size50[40]->in[46] mux_2level_size50[40]->in[47] mux_2level_size50[40]->in[48] mux_2level_size50[40]->in[49] mux_2level_size50[40]->out sram[640]->outb sram[640]->out sram[641]->out sram[641]->outb sram[642]->out sram[642]->outb sram[643]->out sram[643]->outb sram[644]->out sram[644]->outb sram[645]->out sram[645]->outb sram[646]->out sram[646]->outb sram[647]->out sram[647]->outb sram[648]->outb sram[648]->out sram[649]->out sram[649]->outb sram[650]->out sram[650]->outb sram[651]->out sram[651]->outb sram[652]->out sram[652]->outb sram[653]->out sram[653]->outb sram[654]->out sram[654]->outb sram[655]->out sram[655]->outb gvdd_mux_2level_size50[40] 0 mux_2level_size50
***** SRAM bits for MUX[40], level=2, select_path_id=0. *****
*****1000000010000000*****
Xsram[640] sram->in sram[640]->out sram[640]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[640]->out) 0
.nodeset V(sram[640]->outb) vsp
Xsram[641] sram->in sram[641]->out sram[641]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[641]->out) 0
.nodeset V(sram[641]->outb) vsp
Xsram[642] sram->in sram[642]->out sram[642]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[642]->out) 0
.nodeset V(sram[642]->outb) vsp
Xsram[643] sram->in sram[643]->out sram[643]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[643]->out) 0
.nodeset V(sram[643]->outb) vsp
Xsram[644] sram->in sram[644]->out sram[644]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[644]->out) 0
.nodeset V(sram[644]->outb) vsp
Xsram[645] sram->in sram[645]->out sram[645]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[645]->out) 0
.nodeset V(sram[645]->outb) vsp
Xsram[646] sram->in sram[646]->out sram[646]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[646]->out) 0
.nodeset V(sram[646]->outb) vsp
Xsram[647] sram->in sram[647]->out sram[647]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[647]->out) 0
.nodeset V(sram[647]->outb) vsp
Xsram[648] sram->in sram[648]->out sram[648]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[648]->out) 0
.nodeset V(sram[648]->outb) vsp
Xsram[649] sram->in sram[649]->out sram[649]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[649]->out) 0
.nodeset V(sram[649]->outb) vsp
Xsram[650] sram->in sram[650]->out sram[650]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[650]->out) 0
.nodeset V(sram[650]->outb) vsp
Xsram[651] sram->in sram[651]->out sram[651]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[651]->out) 0
.nodeset V(sram[651]->outb) vsp
Xsram[652] sram->in sram[652]->out sram[652]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[652]->out) 0
.nodeset V(sram[652]->outb) vsp
Xsram[653] sram->in sram[653]->out sram[653]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[653]->out) 0
.nodeset V(sram[653]->outb) vsp
Xsram[654] sram->in sram[654]->out sram[654]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[654]->out) 0
.nodeset V(sram[654]->outb) vsp
Xsram[655] sram->in sram[655]->out sram[655]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[655]->out) 0
.nodeset V(sram[655]->outb) vsp
***** Signal mux_2level_size50[40]->in[0] density = 0, probability=0.*****
Vmux_2level_size50[40]->in[0] mux_2level_size50[40]->in[0] 0
+  0
***** Signal mux_2level_size50[40]->in[1] density = 0, probability=0.*****
Vmux_2level_size50[40]->in[1] mux_2level_size50[40]->in[1] 0
+  0
***** Signal mux_2level_size50[40]->in[2] density = 0, probability=0.*****
Vmux_2level_size50[40]->in[2] mux_2level_size50[40]->in[2] 0
+  0
***** Signal mux_2level_size50[40]->in[3] density = 0, probability=0.*****
Vmux_2level_size50[40]->in[3] mux_2level_size50[40]->in[3] 0
+  0
***** Signal mux_2level_size50[40]->in[4] density = 0, probability=0.*****
Vmux_2level_size50[40]->in[4] mux_2level_size50[40]->in[4] 0
+  0
***** Signal mux_2level_size50[40]->in[5] density = 0, probability=0.*****
Vmux_2level_size50[40]->in[5] mux_2level_size50[40]->in[5] 0
+  0
***** Signal mux_2level_size50[40]->in[6] density = 0, probability=0.*****
Vmux_2level_size50[40]->in[6] mux_2level_size50[40]->in[6] 0
+  0
***** Signal mux_2level_size50[40]->in[7] density = 0, probability=0.*****
Vmux_2level_size50[40]->in[7] mux_2level_size50[40]->in[7] 0
+  0
***** Signal mux_2level_size50[40]->in[8] density = 0, probability=0.*****
Vmux_2level_size50[40]->in[8] mux_2level_size50[40]->in[8] 0
+  0
***** Signal mux_2level_size50[40]->in[9] density = 0, probability=0.*****
Vmux_2level_size50[40]->in[9] mux_2level_size50[40]->in[9] 0
+  0
***** Signal mux_2level_size50[40]->in[10] density = 0, probability=0.*****
Vmux_2level_size50[40]->in[10] mux_2level_size50[40]->in[10] 0
+  0
***** Signal mux_2level_size50[40]->in[11] density = 0, probability=0.*****
Vmux_2level_size50[40]->in[11] mux_2level_size50[40]->in[11] 0
+  0
***** Signal mux_2level_size50[40]->in[12] density = 0, probability=0.*****
Vmux_2level_size50[40]->in[12] mux_2level_size50[40]->in[12] 0
+  0
***** Signal mux_2level_size50[40]->in[13] density = 0, probability=0.*****
Vmux_2level_size50[40]->in[13] mux_2level_size50[40]->in[13] 0
+  0
***** Signal mux_2level_size50[40]->in[14] density = 0, probability=0.*****
Vmux_2level_size50[40]->in[14] mux_2level_size50[40]->in[14] 0
+  0
***** Signal mux_2level_size50[40]->in[15] density = 0, probability=0.*****
Vmux_2level_size50[40]->in[15] mux_2level_size50[40]->in[15] 0
+  0
***** Signal mux_2level_size50[40]->in[16] density = 0, probability=0.*****
Vmux_2level_size50[40]->in[16] mux_2level_size50[40]->in[16] 0
+  0
***** Signal mux_2level_size50[40]->in[17] density = 0, probability=0.*****
Vmux_2level_size50[40]->in[17] mux_2level_size50[40]->in[17] 0
+  0
***** Signal mux_2level_size50[40]->in[18] density = 0, probability=0.*****
Vmux_2level_size50[40]->in[18] mux_2level_size50[40]->in[18] 0
+  0
***** Signal mux_2level_size50[40]->in[19] density = 0, probability=0.*****
Vmux_2level_size50[40]->in[19] mux_2level_size50[40]->in[19] 0
+  0
***** Signal mux_2level_size50[40]->in[20] density = 0, probability=0.*****
Vmux_2level_size50[40]->in[20] mux_2level_size50[40]->in[20] 0
+  0
***** Signal mux_2level_size50[40]->in[21] density = 0, probability=0.*****
Vmux_2level_size50[40]->in[21] mux_2level_size50[40]->in[21] 0
+  0
***** Signal mux_2level_size50[40]->in[22] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[40]->in[22] mux_2level_size50[40]->in[22] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[40]->in[23] density = 0, probability=0.*****
Vmux_2level_size50[40]->in[23] mux_2level_size50[40]->in[23] 0
+  0
***** Signal mux_2level_size50[40]->in[24] density = 0, probability=0.*****
Vmux_2level_size50[40]->in[24] mux_2level_size50[40]->in[24] 0
+  0
***** Signal mux_2level_size50[40]->in[25] density = 0, probability=0.*****
Vmux_2level_size50[40]->in[25] mux_2level_size50[40]->in[25] 0
+  0
***** Signal mux_2level_size50[40]->in[26] density = 0, probability=0.*****
Vmux_2level_size50[40]->in[26] mux_2level_size50[40]->in[26] 0
+  0
***** Signal mux_2level_size50[40]->in[27] density = 0, probability=0.*****
Vmux_2level_size50[40]->in[27] mux_2level_size50[40]->in[27] 0
+  0
***** Signal mux_2level_size50[40]->in[28] density = 0, probability=0.*****
Vmux_2level_size50[40]->in[28] mux_2level_size50[40]->in[28] 0
+  0
***** Signal mux_2level_size50[40]->in[29] density = 0, probability=0.*****
Vmux_2level_size50[40]->in[29] mux_2level_size50[40]->in[29] 0
+  0
***** Signal mux_2level_size50[40]->in[30] density = 0, probability=0.*****
Vmux_2level_size50[40]->in[30] mux_2level_size50[40]->in[30] 0
+  0
***** Signal mux_2level_size50[40]->in[31] density = 0, probability=0.*****
Vmux_2level_size50[40]->in[31] mux_2level_size50[40]->in[31] 0
+  0
***** Signal mux_2level_size50[40]->in[32] density = 0, probability=0.*****
Vmux_2level_size50[40]->in[32] mux_2level_size50[40]->in[32] 0
+  0
***** Signal mux_2level_size50[40]->in[33] density = 0, probability=0.*****
Vmux_2level_size50[40]->in[33] mux_2level_size50[40]->in[33] 0
+  0
***** Signal mux_2level_size50[40]->in[34] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[40]->in[34] mux_2level_size50[40]->in[34] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[40]->in[35] density = 0, probability=0.*****
Vmux_2level_size50[40]->in[35] mux_2level_size50[40]->in[35] 0
+  0
***** Signal mux_2level_size50[40]->in[36] density = 0, probability=0.*****
Vmux_2level_size50[40]->in[36] mux_2level_size50[40]->in[36] 0
+  0
***** Signal mux_2level_size50[40]->in[37] density = 0, probability=0.*****
Vmux_2level_size50[40]->in[37] mux_2level_size50[40]->in[37] 0
+  0
***** Signal mux_2level_size50[40]->in[38] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[40]->in[38] mux_2level_size50[40]->in[38] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[40]->in[39] density = 0, probability=0.*****
Vmux_2level_size50[40]->in[39] mux_2level_size50[40]->in[39] 0
+  0
***** Signal mux_2level_size50[40]->in[40] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[40]->in[40] mux_2level_size50[40]->in[40] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[40]->in[41] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[40]->in[41] mux_2level_size50[40]->in[41] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[40]->in[42] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[40]->in[42] mux_2level_size50[40]->in[42] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[40]->in[43] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[40]->in[43] mux_2level_size50[40]->in[43] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[40]->in[44] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[40]->in[44] mux_2level_size50[40]->in[44] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[40]->in[45] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[40]->in[45] mux_2level_size50[40]->in[45] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[40]->in[46] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[40]->in[46] mux_2level_size50[40]->in[46] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[40]->in[47] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[40]->in[47] mux_2level_size50[40]->in[47] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[40]->in[48] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[40]->in[48] mux_2level_size50[40]->in[48] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[40]->in[49] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[40]->in[49] mux_2level_size50[40]->in[49] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
Vgvdd_mux_2level_size50[40] gvdd_mux_2level_size50[40] 0 vsp
***** Measurements *****
***** Rise delay *****
.meas tran delay_rise_idle_mux50[40]_in[4]_crossbar trig v(mux_2level_size50[40]->in[0]) val='input_thres_pct_rise*vsp' rise=1 td='clock_period'
+          targ v(mux_2level_size50[40]->out) val='output_thres_pct_rise*vsp' rise=1 td='clock_period'
***** Fall delay *****
.meas tran delay_fall_idle_mux50[40]_in[4]_crossbar trig v(mux_2level_size50[40]->in[0]) val='input_thres_pct_fall*vsp' fall=1 td='clock_period'
+          targ v(mux_2level_size50[40]->out) val='output_thres_pct_fall*vsp' fall=1 td='clock_period'
***** Rise timing period *****
.meas start_rise_idle_mux50[40]_in[4]_crossbar when v(mux_2level_size50[40]->in[0])='slew_lower_thres_pct_rise*vsp' rise=1 td='clock_period'
.meas tran switch_rise_idle_mux50[40]_in[4]_crossbar trig v(mux_2level_size50[40]->in[0]) val='slew_lower_thres_pct_rise*vsp' rise=1 td='clock_period'
+          targ v(mux_2level_size50[40]->out) val='slew_upper_thres_pct_rise*vsp' rise=1 td='clock_period'
***** Fall timing period *****
.meas start_fall_idle_mux50[40]_in[4]_crossbar when v(mux_2level_size50[40]->in[0])='slew_lower_thres_pct_fall*vsp' fall=1 td='clock_period'
.meas tran switch_fall_idle_mux50[40]_in[4]_crossbar trig v(mux_2level_size50[40]->in[0]) val='slew_lower_thres_pct_fall*vsp' fall=1 td='clock_period'
+          targ v(mux_2level_size50[40]->out) val='slew_upper_thres_pct_fall*vsp' fall=1 td='clock_period'
***** Leakage Power Measurement *****
.meas tran mux_2level_size50[40]_leakage_power avg p(Vgvdd_mux_2level_size50[40]) from=0 to='clock_period'
.meas tran leakage_idle_mux50[40]_in[4]_crossbar param='mux_2level_size50[40]_leakage_power'
***** Dynamic Power Measurement *****
.meas tran mux_2level_size50[40]_dynamic_power avg p(Vgvdd_mux_2level_size50[40]) from='clock_period' to='6*clock_period'
.meas tran mux_2level_size50[40]_energy_per_cycle param='mux_2level_size50[40]_dynamic_power*clock_period'
.meas tran dynamic_power_idle_mux50[40]_in[4]_crossbar  param='mux_2level_size50[40]_dynamic_power'
.meas tran energy_per_cycle_idle_mux50[40]_in[4]_crossbar  param='dynamic_power_idle_mux50[40]_in[4]_crossbar*clock_period'
.meas tran dynamic_rise_idle_mux50[40]_in[4]_crossbar avg p(Vgvdd_mux_2level_size50[40]) from='start_rise_idle_mux50[40]_in[4]_crossbar' to='start_rise_idle_mux50[40]_in[4]_crossbar+switch_rise_idle_mux50[40]_in[4]_crossbar'
.meas tran dynamic_fall_idle_mux50[40]_in[4]_crossbar avg p(Vgvdd_mux_2level_size50[40]) from='start_fall_idle_mux50[40]_in[4]_crossbar' to='start_fall_idle_mux50[40]_in[4]_crossbar+switch_fall_idle_mux50[40]_in[4]_crossbar'
.meas tran sum_leakage_power_mux[0to40]
+          param='sum_leakage_power_mux[0to39]+leakage_idle_mux50[40]_in[4]_crossbar'
.meas tran sum_energy_per_cycle_mux[0to40]
+          param='sum_energy_per_cycle_mux[0to39]+energy_per_cycle_idle_mux50[40]_in[4]_crossbar'
Xload_inv[40]_no0 mux_2level_size50[40]->out mux_2level_size50[40]->out_out[0] gvdd_load 0 inv size=5
.meas tran sum_leakage_power_pb_mux[0to40]
+          param='sum_leakage_power_pb_mux[0to39]+leakage_idle_mux50[40]_in[4]_crossbar'
.meas tran sum_energy_per_cycle_pb_mux[0to40]
+          param='sum_energy_per_cycle_pb_mux[0to39]+energy_per_cycle_idle_mux50[40]_in[4]_crossbar'
Xmux_2level_size50[41] mux_2level_size50[41]->in[0] mux_2level_size50[41]->in[1] mux_2level_size50[41]->in[2] mux_2level_size50[41]->in[3] mux_2level_size50[41]->in[4] mux_2level_size50[41]->in[5] mux_2level_size50[41]->in[6] mux_2level_size50[41]->in[7] mux_2level_size50[41]->in[8] mux_2level_size50[41]->in[9] mux_2level_size50[41]->in[10] mux_2level_size50[41]->in[11] mux_2level_size50[41]->in[12] mux_2level_size50[41]->in[13] mux_2level_size50[41]->in[14] mux_2level_size50[41]->in[15] mux_2level_size50[41]->in[16] mux_2level_size50[41]->in[17] mux_2level_size50[41]->in[18] mux_2level_size50[41]->in[19] mux_2level_size50[41]->in[20] mux_2level_size50[41]->in[21] mux_2level_size50[41]->in[22] mux_2level_size50[41]->in[23] mux_2level_size50[41]->in[24] mux_2level_size50[41]->in[25] mux_2level_size50[41]->in[26] mux_2level_size50[41]->in[27] mux_2level_size50[41]->in[28] mux_2level_size50[41]->in[29] mux_2level_size50[41]->in[30] mux_2level_size50[41]->in[31] mux_2level_size50[41]->in[32] mux_2level_size50[41]->in[33] mux_2level_size50[41]->in[34] mux_2level_size50[41]->in[35] mux_2level_size50[41]->in[36] mux_2level_size50[41]->in[37] mux_2level_size50[41]->in[38] mux_2level_size50[41]->in[39] mux_2level_size50[41]->in[40] mux_2level_size50[41]->in[41] mux_2level_size50[41]->in[42] mux_2level_size50[41]->in[43] mux_2level_size50[41]->in[44] mux_2level_size50[41]->in[45] mux_2level_size50[41]->in[46] mux_2level_size50[41]->in[47] mux_2level_size50[41]->in[48] mux_2level_size50[41]->in[49] mux_2level_size50[41]->out sram[656]->outb sram[656]->out sram[657]->out sram[657]->outb sram[658]->out sram[658]->outb sram[659]->out sram[659]->outb sram[660]->out sram[660]->outb sram[661]->out sram[661]->outb sram[662]->out sram[662]->outb sram[663]->out sram[663]->outb sram[664]->outb sram[664]->out sram[665]->out sram[665]->outb sram[666]->out sram[666]->outb sram[667]->out sram[667]->outb sram[668]->out sram[668]->outb sram[669]->out sram[669]->outb sram[670]->out sram[670]->outb sram[671]->out sram[671]->outb gvdd_mux_2level_size50[41] 0 mux_2level_size50
***** SRAM bits for MUX[41], level=2, select_path_id=0. *****
*****1000000010000000*****
Xsram[656] sram->in sram[656]->out sram[656]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[656]->out) 0
.nodeset V(sram[656]->outb) vsp
Xsram[657] sram->in sram[657]->out sram[657]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[657]->out) 0
.nodeset V(sram[657]->outb) vsp
Xsram[658] sram->in sram[658]->out sram[658]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[658]->out) 0
.nodeset V(sram[658]->outb) vsp
Xsram[659] sram->in sram[659]->out sram[659]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[659]->out) 0
.nodeset V(sram[659]->outb) vsp
Xsram[660] sram->in sram[660]->out sram[660]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[660]->out) 0
.nodeset V(sram[660]->outb) vsp
Xsram[661] sram->in sram[661]->out sram[661]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[661]->out) 0
.nodeset V(sram[661]->outb) vsp
Xsram[662] sram->in sram[662]->out sram[662]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[662]->out) 0
.nodeset V(sram[662]->outb) vsp
Xsram[663] sram->in sram[663]->out sram[663]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[663]->out) 0
.nodeset V(sram[663]->outb) vsp
Xsram[664] sram->in sram[664]->out sram[664]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[664]->out) 0
.nodeset V(sram[664]->outb) vsp
Xsram[665] sram->in sram[665]->out sram[665]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[665]->out) 0
.nodeset V(sram[665]->outb) vsp
Xsram[666] sram->in sram[666]->out sram[666]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[666]->out) 0
.nodeset V(sram[666]->outb) vsp
Xsram[667] sram->in sram[667]->out sram[667]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[667]->out) 0
.nodeset V(sram[667]->outb) vsp
Xsram[668] sram->in sram[668]->out sram[668]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[668]->out) 0
.nodeset V(sram[668]->outb) vsp
Xsram[669] sram->in sram[669]->out sram[669]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[669]->out) 0
.nodeset V(sram[669]->outb) vsp
Xsram[670] sram->in sram[670]->out sram[670]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[670]->out) 0
.nodeset V(sram[670]->outb) vsp
Xsram[671] sram->in sram[671]->out sram[671]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[671]->out) 0
.nodeset V(sram[671]->outb) vsp
***** Signal mux_2level_size50[41]->in[0] density = 0, probability=0.*****
Vmux_2level_size50[41]->in[0] mux_2level_size50[41]->in[0] 0
+  0
***** Signal mux_2level_size50[41]->in[1] density = 0, probability=0.*****
Vmux_2level_size50[41]->in[1] mux_2level_size50[41]->in[1] 0
+  0
***** Signal mux_2level_size50[41]->in[2] density = 0, probability=0.*****
Vmux_2level_size50[41]->in[2] mux_2level_size50[41]->in[2] 0
+  0
***** Signal mux_2level_size50[41]->in[3] density = 0, probability=0.*****
Vmux_2level_size50[41]->in[3] mux_2level_size50[41]->in[3] 0
+  0
***** Signal mux_2level_size50[41]->in[4] density = 0, probability=0.*****
Vmux_2level_size50[41]->in[4] mux_2level_size50[41]->in[4] 0
+  0
***** Signal mux_2level_size50[41]->in[5] density = 0, probability=0.*****
Vmux_2level_size50[41]->in[5] mux_2level_size50[41]->in[5] 0
+  0
***** Signal mux_2level_size50[41]->in[6] density = 0, probability=0.*****
Vmux_2level_size50[41]->in[6] mux_2level_size50[41]->in[6] 0
+  0
***** Signal mux_2level_size50[41]->in[7] density = 0, probability=0.*****
Vmux_2level_size50[41]->in[7] mux_2level_size50[41]->in[7] 0
+  0
***** Signal mux_2level_size50[41]->in[8] density = 0, probability=0.*****
Vmux_2level_size50[41]->in[8] mux_2level_size50[41]->in[8] 0
+  0
***** Signal mux_2level_size50[41]->in[9] density = 0, probability=0.*****
Vmux_2level_size50[41]->in[9] mux_2level_size50[41]->in[9] 0
+  0
***** Signal mux_2level_size50[41]->in[10] density = 0, probability=0.*****
Vmux_2level_size50[41]->in[10] mux_2level_size50[41]->in[10] 0
+  0
***** Signal mux_2level_size50[41]->in[11] density = 0, probability=0.*****
Vmux_2level_size50[41]->in[11] mux_2level_size50[41]->in[11] 0
+  0
***** Signal mux_2level_size50[41]->in[12] density = 0, probability=0.*****
Vmux_2level_size50[41]->in[12] mux_2level_size50[41]->in[12] 0
+  0
***** Signal mux_2level_size50[41]->in[13] density = 0, probability=0.*****
Vmux_2level_size50[41]->in[13] mux_2level_size50[41]->in[13] 0
+  0
***** Signal mux_2level_size50[41]->in[14] density = 0, probability=0.*****
Vmux_2level_size50[41]->in[14] mux_2level_size50[41]->in[14] 0
+  0
***** Signal mux_2level_size50[41]->in[15] density = 0, probability=0.*****
Vmux_2level_size50[41]->in[15] mux_2level_size50[41]->in[15] 0
+  0
***** Signal mux_2level_size50[41]->in[16] density = 0, probability=0.*****
Vmux_2level_size50[41]->in[16] mux_2level_size50[41]->in[16] 0
+  0
***** Signal mux_2level_size50[41]->in[17] density = 0, probability=0.*****
Vmux_2level_size50[41]->in[17] mux_2level_size50[41]->in[17] 0
+  0
***** Signal mux_2level_size50[41]->in[18] density = 0, probability=0.*****
Vmux_2level_size50[41]->in[18] mux_2level_size50[41]->in[18] 0
+  0
***** Signal mux_2level_size50[41]->in[19] density = 0, probability=0.*****
Vmux_2level_size50[41]->in[19] mux_2level_size50[41]->in[19] 0
+  0
***** Signal mux_2level_size50[41]->in[20] density = 0, probability=0.*****
Vmux_2level_size50[41]->in[20] mux_2level_size50[41]->in[20] 0
+  0
***** Signal mux_2level_size50[41]->in[21] density = 0, probability=0.*****
Vmux_2level_size50[41]->in[21] mux_2level_size50[41]->in[21] 0
+  0
***** Signal mux_2level_size50[41]->in[22] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[41]->in[22] mux_2level_size50[41]->in[22] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[41]->in[23] density = 0, probability=0.*****
Vmux_2level_size50[41]->in[23] mux_2level_size50[41]->in[23] 0
+  0
***** Signal mux_2level_size50[41]->in[24] density = 0, probability=0.*****
Vmux_2level_size50[41]->in[24] mux_2level_size50[41]->in[24] 0
+  0
***** Signal mux_2level_size50[41]->in[25] density = 0, probability=0.*****
Vmux_2level_size50[41]->in[25] mux_2level_size50[41]->in[25] 0
+  0
***** Signal mux_2level_size50[41]->in[26] density = 0, probability=0.*****
Vmux_2level_size50[41]->in[26] mux_2level_size50[41]->in[26] 0
+  0
***** Signal mux_2level_size50[41]->in[27] density = 0, probability=0.*****
Vmux_2level_size50[41]->in[27] mux_2level_size50[41]->in[27] 0
+  0
***** Signal mux_2level_size50[41]->in[28] density = 0, probability=0.*****
Vmux_2level_size50[41]->in[28] mux_2level_size50[41]->in[28] 0
+  0
***** Signal mux_2level_size50[41]->in[29] density = 0, probability=0.*****
Vmux_2level_size50[41]->in[29] mux_2level_size50[41]->in[29] 0
+  0
***** Signal mux_2level_size50[41]->in[30] density = 0, probability=0.*****
Vmux_2level_size50[41]->in[30] mux_2level_size50[41]->in[30] 0
+  0
***** Signal mux_2level_size50[41]->in[31] density = 0, probability=0.*****
Vmux_2level_size50[41]->in[31] mux_2level_size50[41]->in[31] 0
+  0
***** Signal mux_2level_size50[41]->in[32] density = 0, probability=0.*****
Vmux_2level_size50[41]->in[32] mux_2level_size50[41]->in[32] 0
+  0
***** Signal mux_2level_size50[41]->in[33] density = 0, probability=0.*****
Vmux_2level_size50[41]->in[33] mux_2level_size50[41]->in[33] 0
+  0
***** Signal mux_2level_size50[41]->in[34] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[41]->in[34] mux_2level_size50[41]->in[34] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[41]->in[35] density = 0, probability=0.*****
Vmux_2level_size50[41]->in[35] mux_2level_size50[41]->in[35] 0
+  0
***** Signal mux_2level_size50[41]->in[36] density = 0, probability=0.*****
Vmux_2level_size50[41]->in[36] mux_2level_size50[41]->in[36] 0
+  0
***** Signal mux_2level_size50[41]->in[37] density = 0, probability=0.*****
Vmux_2level_size50[41]->in[37] mux_2level_size50[41]->in[37] 0
+  0
***** Signal mux_2level_size50[41]->in[38] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[41]->in[38] mux_2level_size50[41]->in[38] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[41]->in[39] density = 0, probability=0.*****
Vmux_2level_size50[41]->in[39] mux_2level_size50[41]->in[39] 0
+  0
***** Signal mux_2level_size50[41]->in[40] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[41]->in[40] mux_2level_size50[41]->in[40] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[41]->in[41] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[41]->in[41] mux_2level_size50[41]->in[41] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[41]->in[42] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[41]->in[42] mux_2level_size50[41]->in[42] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[41]->in[43] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[41]->in[43] mux_2level_size50[41]->in[43] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[41]->in[44] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[41]->in[44] mux_2level_size50[41]->in[44] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[41]->in[45] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[41]->in[45] mux_2level_size50[41]->in[45] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[41]->in[46] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[41]->in[46] mux_2level_size50[41]->in[46] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[41]->in[47] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[41]->in[47] mux_2level_size50[41]->in[47] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[41]->in[48] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[41]->in[48] mux_2level_size50[41]->in[48] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[41]->in[49] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[41]->in[49] mux_2level_size50[41]->in[49] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
Vgvdd_mux_2level_size50[41] gvdd_mux_2level_size50[41] 0 vsp
***** Measurements *****
***** Rise delay *****
.meas tran delay_rise_idle_mux50[41]_in[5]_crossbar trig v(mux_2level_size50[41]->in[0]) val='input_thres_pct_rise*vsp' rise=1 td='clock_period'
+          targ v(mux_2level_size50[41]->out) val='output_thres_pct_rise*vsp' rise=1 td='clock_period'
***** Fall delay *****
.meas tran delay_fall_idle_mux50[41]_in[5]_crossbar trig v(mux_2level_size50[41]->in[0]) val='input_thres_pct_fall*vsp' fall=1 td='clock_period'
+          targ v(mux_2level_size50[41]->out) val='output_thres_pct_fall*vsp' fall=1 td='clock_period'
***** Rise timing period *****
.meas start_rise_idle_mux50[41]_in[5]_crossbar when v(mux_2level_size50[41]->in[0])='slew_lower_thres_pct_rise*vsp' rise=1 td='clock_period'
.meas tran switch_rise_idle_mux50[41]_in[5]_crossbar trig v(mux_2level_size50[41]->in[0]) val='slew_lower_thres_pct_rise*vsp' rise=1 td='clock_period'
+          targ v(mux_2level_size50[41]->out) val='slew_upper_thres_pct_rise*vsp' rise=1 td='clock_period'
***** Fall timing period *****
.meas start_fall_idle_mux50[41]_in[5]_crossbar when v(mux_2level_size50[41]->in[0])='slew_lower_thres_pct_fall*vsp' fall=1 td='clock_period'
.meas tran switch_fall_idle_mux50[41]_in[5]_crossbar trig v(mux_2level_size50[41]->in[0]) val='slew_lower_thres_pct_fall*vsp' fall=1 td='clock_period'
+          targ v(mux_2level_size50[41]->out) val='slew_upper_thres_pct_fall*vsp' fall=1 td='clock_period'
***** Leakage Power Measurement *****
.meas tran mux_2level_size50[41]_leakage_power avg p(Vgvdd_mux_2level_size50[41]) from=0 to='clock_period'
.meas tran leakage_idle_mux50[41]_in[5]_crossbar param='mux_2level_size50[41]_leakage_power'
***** Dynamic Power Measurement *****
.meas tran mux_2level_size50[41]_dynamic_power avg p(Vgvdd_mux_2level_size50[41]) from='clock_period' to='6*clock_period'
.meas tran mux_2level_size50[41]_energy_per_cycle param='mux_2level_size50[41]_dynamic_power*clock_period'
.meas tran dynamic_power_idle_mux50[41]_in[5]_crossbar  param='mux_2level_size50[41]_dynamic_power'
.meas tran energy_per_cycle_idle_mux50[41]_in[5]_crossbar  param='dynamic_power_idle_mux50[41]_in[5]_crossbar*clock_period'
.meas tran dynamic_rise_idle_mux50[41]_in[5]_crossbar avg p(Vgvdd_mux_2level_size50[41]) from='start_rise_idle_mux50[41]_in[5]_crossbar' to='start_rise_idle_mux50[41]_in[5]_crossbar+switch_rise_idle_mux50[41]_in[5]_crossbar'
.meas tran dynamic_fall_idle_mux50[41]_in[5]_crossbar avg p(Vgvdd_mux_2level_size50[41]) from='start_fall_idle_mux50[41]_in[5]_crossbar' to='start_fall_idle_mux50[41]_in[5]_crossbar+switch_fall_idle_mux50[41]_in[5]_crossbar'
.meas tran sum_leakage_power_mux[0to41]
+          param='sum_leakage_power_mux[0to40]+leakage_idle_mux50[41]_in[5]_crossbar'
.meas tran sum_energy_per_cycle_mux[0to41]
+          param='sum_energy_per_cycle_mux[0to40]+energy_per_cycle_idle_mux50[41]_in[5]_crossbar'
Xload_inv[41]_no0 mux_2level_size50[41]->out mux_2level_size50[41]->out_out[0] gvdd_load 0 inv size=5
.meas tran sum_leakage_power_pb_mux[0to41]
+          param='sum_leakage_power_pb_mux[0to40]+leakage_idle_mux50[41]_in[5]_crossbar'
.meas tran sum_energy_per_cycle_pb_mux[0to41]
+          param='sum_energy_per_cycle_pb_mux[0to40]+energy_per_cycle_idle_mux50[41]_in[5]_crossbar'
Xmux_2level_size50[42] mux_2level_size50[42]->in[0] mux_2level_size50[42]->in[1] mux_2level_size50[42]->in[2] mux_2level_size50[42]->in[3] mux_2level_size50[42]->in[4] mux_2level_size50[42]->in[5] mux_2level_size50[42]->in[6] mux_2level_size50[42]->in[7] mux_2level_size50[42]->in[8] mux_2level_size50[42]->in[9] mux_2level_size50[42]->in[10] mux_2level_size50[42]->in[11] mux_2level_size50[42]->in[12] mux_2level_size50[42]->in[13] mux_2level_size50[42]->in[14] mux_2level_size50[42]->in[15] mux_2level_size50[42]->in[16] mux_2level_size50[42]->in[17] mux_2level_size50[42]->in[18] mux_2level_size50[42]->in[19] mux_2level_size50[42]->in[20] mux_2level_size50[42]->in[21] mux_2level_size50[42]->in[22] mux_2level_size50[42]->in[23] mux_2level_size50[42]->in[24] mux_2level_size50[42]->in[25] mux_2level_size50[42]->in[26] mux_2level_size50[42]->in[27] mux_2level_size50[42]->in[28] mux_2level_size50[42]->in[29] mux_2level_size50[42]->in[30] mux_2level_size50[42]->in[31] mux_2level_size50[42]->in[32] mux_2level_size50[42]->in[33] mux_2level_size50[42]->in[34] mux_2level_size50[42]->in[35] mux_2level_size50[42]->in[36] mux_2level_size50[42]->in[37] mux_2level_size50[42]->in[38] mux_2level_size50[42]->in[39] mux_2level_size50[42]->in[40] mux_2level_size50[42]->in[41] mux_2level_size50[42]->in[42] mux_2level_size50[42]->in[43] mux_2level_size50[42]->in[44] mux_2level_size50[42]->in[45] mux_2level_size50[42]->in[46] mux_2level_size50[42]->in[47] mux_2level_size50[42]->in[48] mux_2level_size50[42]->in[49] mux_2level_size50[42]->out sram[672]->outb sram[672]->out sram[673]->out sram[673]->outb sram[674]->out sram[674]->outb sram[675]->out sram[675]->outb sram[676]->out sram[676]->outb sram[677]->out sram[677]->outb sram[678]->out sram[678]->outb sram[679]->out sram[679]->outb sram[680]->outb sram[680]->out sram[681]->out sram[681]->outb sram[682]->out sram[682]->outb sram[683]->out sram[683]->outb sram[684]->out sram[684]->outb sram[685]->out sram[685]->outb sram[686]->out sram[686]->outb sram[687]->out sram[687]->outb gvdd_mux_2level_size50[42] 0 mux_2level_size50
***** SRAM bits for MUX[42], level=2, select_path_id=0. *****
*****1000000010000000*****
Xsram[672] sram->in sram[672]->out sram[672]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[672]->out) 0
.nodeset V(sram[672]->outb) vsp
Xsram[673] sram->in sram[673]->out sram[673]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[673]->out) 0
.nodeset V(sram[673]->outb) vsp
Xsram[674] sram->in sram[674]->out sram[674]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[674]->out) 0
.nodeset V(sram[674]->outb) vsp
Xsram[675] sram->in sram[675]->out sram[675]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[675]->out) 0
.nodeset V(sram[675]->outb) vsp
Xsram[676] sram->in sram[676]->out sram[676]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[676]->out) 0
.nodeset V(sram[676]->outb) vsp
Xsram[677] sram->in sram[677]->out sram[677]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[677]->out) 0
.nodeset V(sram[677]->outb) vsp
Xsram[678] sram->in sram[678]->out sram[678]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[678]->out) 0
.nodeset V(sram[678]->outb) vsp
Xsram[679] sram->in sram[679]->out sram[679]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[679]->out) 0
.nodeset V(sram[679]->outb) vsp
Xsram[680] sram->in sram[680]->out sram[680]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[680]->out) 0
.nodeset V(sram[680]->outb) vsp
Xsram[681] sram->in sram[681]->out sram[681]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[681]->out) 0
.nodeset V(sram[681]->outb) vsp
Xsram[682] sram->in sram[682]->out sram[682]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[682]->out) 0
.nodeset V(sram[682]->outb) vsp
Xsram[683] sram->in sram[683]->out sram[683]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[683]->out) 0
.nodeset V(sram[683]->outb) vsp
Xsram[684] sram->in sram[684]->out sram[684]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[684]->out) 0
.nodeset V(sram[684]->outb) vsp
Xsram[685] sram->in sram[685]->out sram[685]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[685]->out) 0
.nodeset V(sram[685]->outb) vsp
Xsram[686] sram->in sram[686]->out sram[686]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[686]->out) 0
.nodeset V(sram[686]->outb) vsp
Xsram[687] sram->in sram[687]->out sram[687]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[687]->out) 0
.nodeset V(sram[687]->outb) vsp
***** Signal mux_2level_size50[42]->in[0] density = 0, probability=0.*****
Vmux_2level_size50[42]->in[0] mux_2level_size50[42]->in[0] 0
+  0
***** Signal mux_2level_size50[42]->in[1] density = 0, probability=0.*****
Vmux_2level_size50[42]->in[1] mux_2level_size50[42]->in[1] 0
+  0
***** Signal mux_2level_size50[42]->in[2] density = 0, probability=0.*****
Vmux_2level_size50[42]->in[2] mux_2level_size50[42]->in[2] 0
+  0
***** Signal mux_2level_size50[42]->in[3] density = 0, probability=0.*****
Vmux_2level_size50[42]->in[3] mux_2level_size50[42]->in[3] 0
+  0
***** Signal mux_2level_size50[42]->in[4] density = 0, probability=0.*****
Vmux_2level_size50[42]->in[4] mux_2level_size50[42]->in[4] 0
+  0
***** Signal mux_2level_size50[42]->in[5] density = 0, probability=0.*****
Vmux_2level_size50[42]->in[5] mux_2level_size50[42]->in[5] 0
+  0
***** Signal mux_2level_size50[42]->in[6] density = 0, probability=0.*****
Vmux_2level_size50[42]->in[6] mux_2level_size50[42]->in[6] 0
+  0
***** Signal mux_2level_size50[42]->in[7] density = 0, probability=0.*****
Vmux_2level_size50[42]->in[7] mux_2level_size50[42]->in[7] 0
+  0
***** Signal mux_2level_size50[42]->in[8] density = 0, probability=0.*****
Vmux_2level_size50[42]->in[8] mux_2level_size50[42]->in[8] 0
+  0
***** Signal mux_2level_size50[42]->in[9] density = 0, probability=0.*****
Vmux_2level_size50[42]->in[9] mux_2level_size50[42]->in[9] 0
+  0
***** Signal mux_2level_size50[42]->in[10] density = 0, probability=0.*****
Vmux_2level_size50[42]->in[10] mux_2level_size50[42]->in[10] 0
+  0
***** Signal mux_2level_size50[42]->in[11] density = 0, probability=0.*****
Vmux_2level_size50[42]->in[11] mux_2level_size50[42]->in[11] 0
+  0
***** Signal mux_2level_size50[42]->in[12] density = 0, probability=0.*****
Vmux_2level_size50[42]->in[12] mux_2level_size50[42]->in[12] 0
+  0
***** Signal mux_2level_size50[42]->in[13] density = 0, probability=0.*****
Vmux_2level_size50[42]->in[13] mux_2level_size50[42]->in[13] 0
+  0
***** Signal mux_2level_size50[42]->in[14] density = 0, probability=0.*****
Vmux_2level_size50[42]->in[14] mux_2level_size50[42]->in[14] 0
+  0
***** Signal mux_2level_size50[42]->in[15] density = 0, probability=0.*****
Vmux_2level_size50[42]->in[15] mux_2level_size50[42]->in[15] 0
+  0
***** Signal mux_2level_size50[42]->in[16] density = 0, probability=0.*****
Vmux_2level_size50[42]->in[16] mux_2level_size50[42]->in[16] 0
+  0
***** Signal mux_2level_size50[42]->in[17] density = 0, probability=0.*****
Vmux_2level_size50[42]->in[17] mux_2level_size50[42]->in[17] 0
+  0
***** Signal mux_2level_size50[42]->in[18] density = 0, probability=0.*****
Vmux_2level_size50[42]->in[18] mux_2level_size50[42]->in[18] 0
+  0
***** Signal mux_2level_size50[42]->in[19] density = 0, probability=0.*****
Vmux_2level_size50[42]->in[19] mux_2level_size50[42]->in[19] 0
+  0
***** Signal mux_2level_size50[42]->in[20] density = 0, probability=0.*****
Vmux_2level_size50[42]->in[20] mux_2level_size50[42]->in[20] 0
+  0
***** Signal mux_2level_size50[42]->in[21] density = 0, probability=0.*****
Vmux_2level_size50[42]->in[21] mux_2level_size50[42]->in[21] 0
+  0
***** Signal mux_2level_size50[42]->in[22] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[42]->in[22] mux_2level_size50[42]->in[22] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[42]->in[23] density = 0, probability=0.*****
Vmux_2level_size50[42]->in[23] mux_2level_size50[42]->in[23] 0
+  0
***** Signal mux_2level_size50[42]->in[24] density = 0, probability=0.*****
Vmux_2level_size50[42]->in[24] mux_2level_size50[42]->in[24] 0
+  0
***** Signal mux_2level_size50[42]->in[25] density = 0, probability=0.*****
Vmux_2level_size50[42]->in[25] mux_2level_size50[42]->in[25] 0
+  0
***** Signal mux_2level_size50[42]->in[26] density = 0, probability=0.*****
Vmux_2level_size50[42]->in[26] mux_2level_size50[42]->in[26] 0
+  0
***** Signal mux_2level_size50[42]->in[27] density = 0, probability=0.*****
Vmux_2level_size50[42]->in[27] mux_2level_size50[42]->in[27] 0
+  0
***** Signal mux_2level_size50[42]->in[28] density = 0, probability=0.*****
Vmux_2level_size50[42]->in[28] mux_2level_size50[42]->in[28] 0
+  0
***** Signal mux_2level_size50[42]->in[29] density = 0, probability=0.*****
Vmux_2level_size50[42]->in[29] mux_2level_size50[42]->in[29] 0
+  0
***** Signal mux_2level_size50[42]->in[30] density = 0, probability=0.*****
Vmux_2level_size50[42]->in[30] mux_2level_size50[42]->in[30] 0
+  0
***** Signal mux_2level_size50[42]->in[31] density = 0, probability=0.*****
Vmux_2level_size50[42]->in[31] mux_2level_size50[42]->in[31] 0
+  0
***** Signal mux_2level_size50[42]->in[32] density = 0, probability=0.*****
Vmux_2level_size50[42]->in[32] mux_2level_size50[42]->in[32] 0
+  0
***** Signal mux_2level_size50[42]->in[33] density = 0, probability=0.*****
Vmux_2level_size50[42]->in[33] mux_2level_size50[42]->in[33] 0
+  0
***** Signal mux_2level_size50[42]->in[34] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[42]->in[34] mux_2level_size50[42]->in[34] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[42]->in[35] density = 0, probability=0.*****
Vmux_2level_size50[42]->in[35] mux_2level_size50[42]->in[35] 0
+  0
***** Signal mux_2level_size50[42]->in[36] density = 0, probability=0.*****
Vmux_2level_size50[42]->in[36] mux_2level_size50[42]->in[36] 0
+  0
***** Signal mux_2level_size50[42]->in[37] density = 0, probability=0.*****
Vmux_2level_size50[42]->in[37] mux_2level_size50[42]->in[37] 0
+  0
***** Signal mux_2level_size50[42]->in[38] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[42]->in[38] mux_2level_size50[42]->in[38] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[42]->in[39] density = 0, probability=0.*****
Vmux_2level_size50[42]->in[39] mux_2level_size50[42]->in[39] 0
+  0
***** Signal mux_2level_size50[42]->in[40] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[42]->in[40] mux_2level_size50[42]->in[40] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[42]->in[41] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[42]->in[41] mux_2level_size50[42]->in[41] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[42]->in[42] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[42]->in[42] mux_2level_size50[42]->in[42] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[42]->in[43] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[42]->in[43] mux_2level_size50[42]->in[43] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[42]->in[44] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[42]->in[44] mux_2level_size50[42]->in[44] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[42]->in[45] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[42]->in[45] mux_2level_size50[42]->in[45] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[42]->in[46] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[42]->in[46] mux_2level_size50[42]->in[46] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[42]->in[47] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[42]->in[47] mux_2level_size50[42]->in[47] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[42]->in[48] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[42]->in[48] mux_2level_size50[42]->in[48] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[42]->in[49] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[42]->in[49] mux_2level_size50[42]->in[49] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
Vgvdd_mux_2level_size50[42] gvdd_mux_2level_size50[42] 0 vsp
***** Measurements *****
***** Rise delay *****
.meas tran delay_rise_idle_mux50[42]_in[0]_crossbar trig v(mux_2level_size50[42]->in[0]) val='input_thres_pct_rise*vsp' rise=1 td='clock_period'
+          targ v(mux_2level_size50[42]->out) val='output_thres_pct_rise*vsp' rise=1 td='clock_period'
***** Fall delay *****
.meas tran delay_fall_idle_mux50[42]_in[0]_crossbar trig v(mux_2level_size50[42]->in[0]) val='input_thres_pct_fall*vsp' fall=1 td='clock_period'
+          targ v(mux_2level_size50[42]->out) val='output_thres_pct_fall*vsp' fall=1 td='clock_period'
***** Rise timing period *****
.meas start_rise_idle_mux50[42]_in[0]_crossbar when v(mux_2level_size50[42]->in[0])='slew_lower_thres_pct_rise*vsp' rise=1 td='clock_period'
.meas tran switch_rise_idle_mux50[42]_in[0]_crossbar trig v(mux_2level_size50[42]->in[0]) val='slew_lower_thres_pct_rise*vsp' rise=1 td='clock_period'
+          targ v(mux_2level_size50[42]->out) val='slew_upper_thres_pct_rise*vsp' rise=1 td='clock_period'
***** Fall timing period *****
.meas start_fall_idle_mux50[42]_in[0]_crossbar when v(mux_2level_size50[42]->in[0])='slew_lower_thres_pct_fall*vsp' fall=1 td='clock_period'
.meas tran switch_fall_idle_mux50[42]_in[0]_crossbar trig v(mux_2level_size50[42]->in[0]) val='slew_lower_thres_pct_fall*vsp' fall=1 td='clock_period'
+          targ v(mux_2level_size50[42]->out) val='slew_upper_thres_pct_fall*vsp' fall=1 td='clock_period'
***** Leakage Power Measurement *****
.meas tran mux_2level_size50[42]_leakage_power avg p(Vgvdd_mux_2level_size50[42]) from=0 to='clock_period'
.meas tran leakage_idle_mux50[42]_in[0]_crossbar param='mux_2level_size50[42]_leakage_power'
***** Dynamic Power Measurement *****
.meas tran mux_2level_size50[42]_dynamic_power avg p(Vgvdd_mux_2level_size50[42]) from='clock_period' to='6*clock_period'
.meas tran mux_2level_size50[42]_energy_per_cycle param='mux_2level_size50[42]_dynamic_power*clock_period'
.meas tran dynamic_power_idle_mux50[42]_in[0]_crossbar  param='mux_2level_size50[42]_dynamic_power'
.meas tran energy_per_cycle_idle_mux50[42]_in[0]_crossbar  param='dynamic_power_idle_mux50[42]_in[0]_crossbar*clock_period'
.meas tran dynamic_rise_idle_mux50[42]_in[0]_crossbar avg p(Vgvdd_mux_2level_size50[42]) from='start_rise_idle_mux50[42]_in[0]_crossbar' to='start_rise_idle_mux50[42]_in[0]_crossbar+switch_rise_idle_mux50[42]_in[0]_crossbar'
.meas tran dynamic_fall_idle_mux50[42]_in[0]_crossbar avg p(Vgvdd_mux_2level_size50[42]) from='start_fall_idle_mux50[42]_in[0]_crossbar' to='start_fall_idle_mux50[42]_in[0]_crossbar+switch_fall_idle_mux50[42]_in[0]_crossbar'
.meas tran sum_leakage_power_mux[0to42]
+          param='sum_leakage_power_mux[0to41]+leakage_idle_mux50[42]_in[0]_crossbar'
.meas tran sum_energy_per_cycle_mux[0to42]
+          param='sum_energy_per_cycle_mux[0to41]+energy_per_cycle_idle_mux50[42]_in[0]_crossbar'
Xload_inv[42]_no0 mux_2level_size50[42]->out mux_2level_size50[42]->out_out[0] gvdd_load 0 inv size=5
.meas tran sum_leakage_power_pb_mux[0to42]
+          param='sum_leakage_power_pb_mux[0to41]+leakage_idle_mux50[42]_in[0]_crossbar'
.meas tran sum_energy_per_cycle_pb_mux[0to42]
+          param='sum_energy_per_cycle_pb_mux[0to41]+energy_per_cycle_idle_mux50[42]_in[0]_crossbar'
Xmux_2level_size50[43] mux_2level_size50[43]->in[0] mux_2level_size50[43]->in[1] mux_2level_size50[43]->in[2] mux_2level_size50[43]->in[3] mux_2level_size50[43]->in[4] mux_2level_size50[43]->in[5] mux_2level_size50[43]->in[6] mux_2level_size50[43]->in[7] mux_2level_size50[43]->in[8] mux_2level_size50[43]->in[9] mux_2level_size50[43]->in[10] mux_2level_size50[43]->in[11] mux_2level_size50[43]->in[12] mux_2level_size50[43]->in[13] mux_2level_size50[43]->in[14] mux_2level_size50[43]->in[15] mux_2level_size50[43]->in[16] mux_2level_size50[43]->in[17] mux_2level_size50[43]->in[18] mux_2level_size50[43]->in[19] mux_2level_size50[43]->in[20] mux_2level_size50[43]->in[21] mux_2level_size50[43]->in[22] mux_2level_size50[43]->in[23] mux_2level_size50[43]->in[24] mux_2level_size50[43]->in[25] mux_2level_size50[43]->in[26] mux_2level_size50[43]->in[27] mux_2level_size50[43]->in[28] mux_2level_size50[43]->in[29] mux_2level_size50[43]->in[30] mux_2level_size50[43]->in[31] mux_2level_size50[43]->in[32] mux_2level_size50[43]->in[33] mux_2level_size50[43]->in[34] mux_2level_size50[43]->in[35] mux_2level_size50[43]->in[36] mux_2level_size50[43]->in[37] mux_2level_size50[43]->in[38] mux_2level_size50[43]->in[39] mux_2level_size50[43]->in[40] mux_2level_size50[43]->in[41] mux_2level_size50[43]->in[42] mux_2level_size50[43]->in[43] mux_2level_size50[43]->in[44] mux_2level_size50[43]->in[45] mux_2level_size50[43]->in[46] mux_2level_size50[43]->in[47] mux_2level_size50[43]->in[48] mux_2level_size50[43]->in[49] mux_2level_size50[43]->out sram[688]->outb sram[688]->out sram[689]->out sram[689]->outb sram[690]->out sram[690]->outb sram[691]->out sram[691]->outb sram[692]->out sram[692]->outb sram[693]->out sram[693]->outb sram[694]->out sram[694]->outb sram[695]->out sram[695]->outb sram[696]->outb sram[696]->out sram[697]->out sram[697]->outb sram[698]->out sram[698]->outb sram[699]->out sram[699]->outb sram[700]->out sram[700]->outb sram[701]->out sram[701]->outb sram[702]->out sram[702]->outb sram[703]->out sram[703]->outb gvdd_mux_2level_size50[43] 0 mux_2level_size50
***** SRAM bits for MUX[43], level=2, select_path_id=0. *****
*****1000000010000000*****
Xsram[688] sram->in sram[688]->out sram[688]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[688]->out) 0
.nodeset V(sram[688]->outb) vsp
Xsram[689] sram->in sram[689]->out sram[689]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[689]->out) 0
.nodeset V(sram[689]->outb) vsp
Xsram[690] sram->in sram[690]->out sram[690]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[690]->out) 0
.nodeset V(sram[690]->outb) vsp
Xsram[691] sram->in sram[691]->out sram[691]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[691]->out) 0
.nodeset V(sram[691]->outb) vsp
Xsram[692] sram->in sram[692]->out sram[692]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[692]->out) 0
.nodeset V(sram[692]->outb) vsp
Xsram[693] sram->in sram[693]->out sram[693]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[693]->out) 0
.nodeset V(sram[693]->outb) vsp
Xsram[694] sram->in sram[694]->out sram[694]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[694]->out) 0
.nodeset V(sram[694]->outb) vsp
Xsram[695] sram->in sram[695]->out sram[695]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[695]->out) 0
.nodeset V(sram[695]->outb) vsp
Xsram[696] sram->in sram[696]->out sram[696]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[696]->out) 0
.nodeset V(sram[696]->outb) vsp
Xsram[697] sram->in sram[697]->out sram[697]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[697]->out) 0
.nodeset V(sram[697]->outb) vsp
Xsram[698] sram->in sram[698]->out sram[698]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[698]->out) 0
.nodeset V(sram[698]->outb) vsp
Xsram[699] sram->in sram[699]->out sram[699]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[699]->out) 0
.nodeset V(sram[699]->outb) vsp
Xsram[700] sram->in sram[700]->out sram[700]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[700]->out) 0
.nodeset V(sram[700]->outb) vsp
Xsram[701] sram->in sram[701]->out sram[701]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[701]->out) 0
.nodeset V(sram[701]->outb) vsp
Xsram[702] sram->in sram[702]->out sram[702]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[702]->out) 0
.nodeset V(sram[702]->outb) vsp
Xsram[703] sram->in sram[703]->out sram[703]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[703]->out) 0
.nodeset V(sram[703]->outb) vsp
***** Signal mux_2level_size50[43]->in[0] density = 0, probability=0.*****
Vmux_2level_size50[43]->in[0] mux_2level_size50[43]->in[0] 0
+  0
***** Signal mux_2level_size50[43]->in[1] density = 0, probability=0.*****
Vmux_2level_size50[43]->in[1] mux_2level_size50[43]->in[1] 0
+  0
***** Signal mux_2level_size50[43]->in[2] density = 0, probability=0.*****
Vmux_2level_size50[43]->in[2] mux_2level_size50[43]->in[2] 0
+  0
***** Signal mux_2level_size50[43]->in[3] density = 0, probability=0.*****
Vmux_2level_size50[43]->in[3] mux_2level_size50[43]->in[3] 0
+  0
***** Signal mux_2level_size50[43]->in[4] density = 0, probability=0.*****
Vmux_2level_size50[43]->in[4] mux_2level_size50[43]->in[4] 0
+  0
***** Signal mux_2level_size50[43]->in[5] density = 0, probability=0.*****
Vmux_2level_size50[43]->in[5] mux_2level_size50[43]->in[5] 0
+  0
***** Signal mux_2level_size50[43]->in[6] density = 0, probability=0.*****
Vmux_2level_size50[43]->in[6] mux_2level_size50[43]->in[6] 0
+  0
***** Signal mux_2level_size50[43]->in[7] density = 0, probability=0.*****
Vmux_2level_size50[43]->in[7] mux_2level_size50[43]->in[7] 0
+  0
***** Signal mux_2level_size50[43]->in[8] density = 0, probability=0.*****
Vmux_2level_size50[43]->in[8] mux_2level_size50[43]->in[8] 0
+  0
***** Signal mux_2level_size50[43]->in[9] density = 0, probability=0.*****
Vmux_2level_size50[43]->in[9] mux_2level_size50[43]->in[9] 0
+  0
***** Signal mux_2level_size50[43]->in[10] density = 0, probability=0.*****
Vmux_2level_size50[43]->in[10] mux_2level_size50[43]->in[10] 0
+  0
***** Signal mux_2level_size50[43]->in[11] density = 0, probability=0.*****
Vmux_2level_size50[43]->in[11] mux_2level_size50[43]->in[11] 0
+  0
***** Signal mux_2level_size50[43]->in[12] density = 0, probability=0.*****
Vmux_2level_size50[43]->in[12] mux_2level_size50[43]->in[12] 0
+  0
***** Signal mux_2level_size50[43]->in[13] density = 0, probability=0.*****
Vmux_2level_size50[43]->in[13] mux_2level_size50[43]->in[13] 0
+  0
***** Signal mux_2level_size50[43]->in[14] density = 0, probability=0.*****
Vmux_2level_size50[43]->in[14] mux_2level_size50[43]->in[14] 0
+  0
***** Signal mux_2level_size50[43]->in[15] density = 0, probability=0.*****
Vmux_2level_size50[43]->in[15] mux_2level_size50[43]->in[15] 0
+  0
***** Signal mux_2level_size50[43]->in[16] density = 0, probability=0.*****
Vmux_2level_size50[43]->in[16] mux_2level_size50[43]->in[16] 0
+  0
***** Signal mux_2level_size50[43]->in[17] density = 0, probability=0.*****
Vmux_2level_size50[43]->in[17] mux_2level_size50[43]->in[17] 0
+  0
***** Signal mux_2level_size50[43]->in[18] density = 0, probability=0.*****
Vmux_2level_size50[43]->in[18] mux_2level_size50[43]->in[18] 0
+  0
***** Signal mux_2level_size50[43]->in[19] density = 0, probability=0.*****
Vmux_2level_size50[43]->in[19] mux_2level_size50[43]->in[19] 0
+  0
***** Signal mux_2level_size50[43]->in[20] density = 0, probability=0.*****
Vmux_2level_size50[43]->in[20] mux_2level_size50[43]->in[20] 0
+  0
***** Signal mux_2level_size50[43]->in[21] density = 0, probability=0.*****
Vmux_2level_size50[43]->in[21] mux_2level_size50[43]->in[21] 0
+  0
***** Signal mux_2level_size50[43]->in[22] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[43]->in[22] mux_2level_size50[43]->in[22] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[43]->in[23] density = 0, probability=0.*****
Vmux_2level_size50[43]->in[23] mux_2level_size50[43]->in[23] 0
+  0
***** Signal mux_2level_size50[43]->in[24] density = 0, probability=0.*****
Vmux_2level_size50[43]->in[24] mux_2level_size50[43]->in[24] 0
+  0
***** Signal mux_2level_size50[43]->in[25] density = 0, probability=0.*****
Vmux_2level_size50[43]->in[25] mux_2level_size50[43]->in[25] 0
+  0
***** Signal mux_2level_size50[43]->in[26] density = 0, probability=0.*****
Vmux_2level_size50[43]->in[26] mux_2level_size50[43]->in[26] 0
+  0
***** Signal mux_2level_size50[43]->in[27] density = 0, probability=0.*****
Vmux_2level_size50[43]->in[27] mux_2level_size50[43]->in[27] 0
+  0
***** Signal mux_2level_size50[43]->in[28] density = 0, probability=0.*****
Vmux_2level_size50[43]->in[28] mux_2level_size50[43]->in[28] 0
+  0
***** Signal mux_2level_size50[43]->in[29] density = 0, probability=0.*****
Vmux_2level_size50[43]->in[29] mux_2level_size50[43]->in[29] 0
+  0
***** Signal mux_2level_size50[43]->in[30] density = 0, probability=0.*****
Vmux_2level_size50[43]->in[30] mux_2level_size50[43]->in[30] 0
+  0
***** Signal mux_2level_size50[43]->in[31] density = 0, probability=0.*****
Vmux_2level_size50[43]->in[31] mux_2level_size50[43]->in[31] 0
+  0
***** Signal mux_2level_size50[43]->in[32] density = 0, probability=0.*****
Vmux_2level_size50[43]->in[32] mux_2level_size50[43]->in[32] 0
+  0
***** Signal mux_2level_size50[43]->in[33] density = 0, probability=0.*****
Vmux_2level_size50[43]->in[33] mux_2level_size50[43]->in[33] 0
+  0
***** Signal mux_2level_size50[43]->in[34] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[43]->in[34] mux_2level_size50[43]->in[34] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[43]->in[35] density = 0, probability=0.*****
Vmux_2level_size50[43]->in[35] mux_2level_size50[43]->in[35] 0
+  0
***** Signal mux_2level_size50[43]->in[36] density = 0, probability=0.*****
Vmux_2level_size50[43]->in[36] mux_2level_size50[43]->in[36] 0
+  0
***** Signal mux_2level_size50[43]->in[37] density = 0, probability=0.*****
Vmux_2level_size50[43]->in[37] mux_2level_size50[43]->in[37] 0
+  0
***** Signal mux_2level_size50[43]->in[38] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[43]->in[38] mux_2level_size50[43]->in[38] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[43]->in[39] density = 0, probability=0.*****
Vmux_2level_size50[43]->in[39] mux_2level_size50[43]->in[39] 0
+  0
***** Signal mux_2level_size50[43]->in[40] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[43]->in[40] mux_2level_size50[43]->in[40] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[43]->in[41] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[43]->in[41] mux_2level_size50[43]->in[41] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[43]->in[42] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[43]->in[42] mux_2level_size50[43]->in[42] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[43]->in[43] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[43]->in[43] mux_2level_size50[43]->in[43] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[43]->in[44] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[43]->in[44] mux_2level_size50[43]->in[44] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[43]->in[45] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[43]->in[45] mux_2level_size50[43]->in[45] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[43]->in[46] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[43]->in[46] mux_2level_size50[43]->in[46] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[43]->in[47] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[43]->in[47] mux_2level_size50[43]->in[47] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[43]->in[48] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[43]->in[48] mux_2level_size50[43]->in[48] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[43]->in[49] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[43]->in[49] mux_2level_size50[43]->in[49] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
Vgvdd_mux_2level_size50[43] gvdd_mux_2level_size50[43] 0 vsp
***** Measurements *****
***** Rise delay *****
.meas tran delay_rise_idle_mux50[43]_in[1]_crossbar trig v(mux_2level_size50[43]->in[0]) val='input_thres_pct_rise*vsp' rise=1 td='clock_period'
+          targ v(mux_2level_size50[43]->out) val='output_thres_pct_rise*vsp' rise=1 td='clock_period'
***** Fall delay *****
.meas tran delay_fall_idle_mux50[43]_in[1]_crossbar trig v(mux_2level_size50[43]->in[0]) val='input_thres_pct_fall*vsp' fall=1 td='clock_period'
+          targ v(mux_2level_size50[43]->out) val='output_thres_pct_fall*vsp' fall=1 td='clock_period'
***** Rise timing period *****
.meas start_rise_idle_mux50[43]_in[1]_crossbar when v(mux_2level_size50[43]->in[0])='slew_lower_thres_pct_rise*vsp' rise=1 td='clock_period'
.meas tran switch_rise_idle_mux50[43]_in[1]_crossbar trig v(mux_2level_size50[43]->in[0]) val='slew_lower_thres_pct_rise*vsp' rise=1 td='clock_period'
+          targ v(mux_2level_size50[43]->out) val='slew_upper_thres_pct_rise*vsp' rise=1 td='clock_period'
***** Fall timing period *****
.meas start_fall_idle_mux50[43]_in[1]_crossbar when v(mux_2level_size50[43]->in[0])='slew_lower_thres_pct_fall*vsp' fall=1 td='clock_period'
.meas tran switch_fall_idle_mux50[43]_in[1]_crossbar trig v(mux_2level_size50[43]->in[0]) val='slew_lower_thres_pct_fall*vsp' fall=1 td='clock_period'
+          targ v(mux_2level_size50[43]->out) val='slew_upper_thres_pct_fall*vsp' fall=1 td='clock_period'
***** Leakage Power Measurement *****
.meas tran mux_2level_size50[43]_leakage_power avg p(Vgvdd_mux_2level_size50[43]) from=0 to='clock_period'
.meas tran leakage_idle_mux50[43]_in[1]_crossbar param='mux_2level_size50[43]_leakage_power'
***** Dynamic Power Measurement *****
.meas tran mux_2level_size50[43]_dynamic_power avg p(Vgvdd_mux_2level_size50[43]) from='clock_period' to='6*clock_period'
.meas tran mux_2level_size50[43]_energy_per_cycle param='mux_2level_size50[43]_dynamic_power*clock_period'
.meas tran dynamic_power_idle_mux50[43]_in[1]_crossbar  param='mux_2level_size50[43]_dynamic_power'
.meas tran energy_per_cycle_idle_mux50[43]_in[1]_crossbar  param='dynamic_power_idle_mux50[43]_in[1]_crossbar*clock_period'
.meas tran dynamic_rise_idle_mux50[43]_in[1]_crossbar avg p(Vgvdd_mux_2level_size50[43]) from='start_rise_idle_mux50[43]_in[1]_crossbar' to='start_rise_idle_mux50[43]_in[1]_crossbar+switch_rise_idle_mux50[43]_in[1]_crossbar'
.meas tran dynamic_fall_idle_mux50[43]_in[1]_crossbar avg p(Vgvdd_mux_2level_size50[43]) from='start_fall_idle_mux50[43]_in[1]_crossbar' to='start_fall_idle_mux50[43]_in[1]_crossbar+switch_fall_idle_mux50[43]_in[1]_crossbar'
.meas tran sum_leakage_power_mux[0to43]
+          param='sum_leakage_power_mux[0to42]+leakage_idle_mux50[43]_in[1]_crossbar'
.meas tran sum_energy_per_cycle_mux[0to43]
+          param='sum_energy_per_cycle_mux[0to42]+energy_per_cycle_idle_mux50[43]_in[1]_crossbar'
Xload_inv[43]_no0 mux_2level_size50[43]->out mux_2level_size50[43]->out_out[0] gvdd_load 0 inv size=5
.meas tran sum_leakage_power_pb_mux[0to43]
+          param='sum_leakage_power_pb_mux[0to42]+leakage_idle_mux50[43]_in[1]_crossbar'
.meas tran sum_energy_per_cycle_pb_mux[0to43]
+          param='sum_energy_per_cycle_pb_mux[0to42]+energy_per_cycle_idle_mux50[43]_in[1]_crossbar'
Xmux_2level_size50[44] mux_2level_size50[44]->in[0] mux_2level_size50[44]->in[1] mux_2level_size50[44]->in[2] mux_2level_size50[44]->in[3] mux_2level_size50[44]->in[4] mux_2level_size50[44]->in[5] mux_2level_size50[44]->in[6] mux_2level_size50[44]->in[7] mux_2level_size50[44]->in[8] mux_2level_size50[44]->in[9] mux_2level_size50[44]->in[10] mux_2level_size50[44]->in[11] mux_2level_size50[44]->in[12] mux_2level_size50[44]->in[13] mux_2level_size50[44]->in[14] mux_2level_size50[44]->in[15] mux_2level_size50[44]->in[16] mux_2level_size50[44]->in[17] mux_2level_size50[44]->in[18] mux_2level_size50[44]->in[19] mux_2level_size50[44]->in[20] mux_2level_size50[44]->in[21] mux_2level_size50[44]->in[22] mux_2level_size50[44]->in[23] mux_2level_size50[44]->in[24] mux_2level_size50[44]->in[25] mux_2level_size50[44]->in[26] mux_2level_size50[44]->in[27] mux_2level_size50[44]->in[28] mux_2level_size50[44]->in[29] mux_2level_size50[44]->in[30] mux_2level_size50[44]->in[31] mux_2level_size50[44]->in[32] mux_2level_size50[44]->in[33] mux_2level_size50[44]->in[34] mux_2level_size50[44]->in[35] mux_2level_size50[44]->in[36] mux_2level_size50[44]->in[37] mux_2level_size50[44]->in[38] mux_2level_size50[44]->in[39] mux_2level_size50[44]->in[40] mux_2level_size50[44]->in[41] mux_2level_size50[44]->in[42] mux_2level_size50[44]->in[43] mux_2level_size50[44]->in[44] mux_2level_size50[44]->in[45] mux_2level_size50[44]->in[46] mux_2level_size50[44]->in[47] mux_2level_size50[44]->in[48] mux_2level_size50[44]->in[49] mux_2level_size50[44]->out sram[704]->outb sram[704]->out sram[705]->out sram[705]->outb sram[706]->out sram[706]->outb sram[707]->out sram[707]->outb sram[708]->out sram[708]->outb sram[709]->out sram[709]->outb sram[710]->out sram[710]->outb sram[711]->out sram[711]->outb sram[712]->outb sram[712]->out sram[713]->out sram[713]->outb sram[714]->out sram[714]->outb sram[715]->out sram[715]->outb sram[716]->out sram[716]->outb sram[717]->out sram[717]->outb sram[718]->out sram[718]->outb sram[719]->out sram[719]->outb gvdd_mux_2level_size50[44] 0 mux_2level_size50
***** SRAM bits for MUX[44], level=2, select_path_id=0. *****
*****1000000010000000*****
Xsram[704] sram->in sram[704]->out sram[704]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[704]->out) 0
.nodeset V(sram[704]->outb) vsp
Xsram[705] sram->in sram[705]->out sram[705]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[705]->out) 0
.nodeset V(sram[705]->outb) vsp
Xsram[706] sram->in sram[706]->out sram[706]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[706]->out) 0
.nodeset V(sram[706]->outb) vsp
Xsram[707] sram->in sram[707]->out sram[707]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[707]->out) 0
.nodeset V(sram[707]->outb) vsp
Xsram[708] sram->in sram[708]->out sram[708]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[708]->out) 0
.nodeset V(sram[708]->outb) vsp
Xsram[709] sram->in sram[709]->out sram[709]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[709]->out) 0
.nodeset V(sram[709]->outb) vsp
Xsram[710] sram->in sram[710]->out sram[710]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[710]->out) 0
.nodeset V(sram[710]->outb) vsp
Xsram[711] sram->in sram[711]->out sram[711]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[711]->out) 0
.nodeset V(sram[711]->outb) vsp
Xsram[712] sram->in sram[712]->out sram[712]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[712]->out) 0
.nodeset V(sram[712]->outb) vsp
Xsram[713] sram->in sram[713]->out sram[713]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[713]->out) 0
.nodeset V(sram[713]->outb) vsp
Xsram[714] sram->in sram[714]->out sram[714]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[714]->out) 0
.nodeset V(sram[714]->outb) vsp
Xsram[715] sram->in sram[715]->out sram[715]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[715]->out) 0
.nodeset V(sram[715]->outb) vsp
Xsram[716] sram->in sram[716]->out sram[716]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[716]->out) 0
.nodeset V(sram[716]->outb) vsp
Xsram[717] sram->in sram[717]->out sram[717]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[717]->out) 0
.nodeset V(sram[717]->outb) vsp
Xsram[718] sram->in sram[718]->out sram[718]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[718]->out) 0
.nodeset V(sram[718]->outb) vsp
Xsram[719] sram->in sram[719]->out sram[719]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[719]->out) 0
.nodeset V(sram[719]->outb) vsp
***** Signal mux_2level_size50[44]->in[0] density = 0, probability=0.*****
Vmux_2level_size50[44]->in[0] mux_2level_size50[44]->in[0] 0
+  0
***** Signal mux_2level_size50[44]->in[1] density = 0, probability=0.*****
Vmux_2level_size50[44]->in[1] mux_2level_size50[44]->in[1] 0
+  0
***** Signal mux_2level_size50[44]->in[2] density = 0, probability=0.*****
Vmux_2level_size50[44]->in[2] mux_2level_size50[44]->in[2] 0
+  0
***** Signal mux_2level_size50[44]->in[3] density = 0, probability=0.*****
Vmux_2level_size50[44]->in[3] mux_2level_size50[44]->in[3] 0
+  0
***** Signal mux_2level_size50[44]->in[4] density = 0, probability=0.*****
Vmux_2level_size50[44]->in[4] mux_2level_size50[44]->in[4] 0
+  0
***** Signal mux_2level_size50[44]->in[5] density = 0, probability=0.*****
Vmux_2level_size50[44]->in[5] mux_2level_size50[44]->in[5] 0
+  0
***** Signal mux_2level_size50[44]->in[6] density = 0, probability=0.*****
Vmux_2level_size50[44]->in[6] mux_2level_size50[44]->in[6] 0
+  0
***** Signal mux_2level_size50[44]->in[7] density = 0, probability=0.*****
Vmux_2level_size50[44]->in[7] mux_2level_size50[44]->in[7] 0
+  0
***** Signal mux_2level_size50[44]->in[8] density = 0, probability=0.*****
Vmux_2level_size50[44]->in[8] mux_2level_size50[44]->in[8] 0
+  0
***** Signal mux_2level_size50[44]->in[9] density = 0, probability=0.*****
Vmux_2level_size50[44]->in[9] mux_2level_size50[44]->in[9] 0
+  0
***** Signal mux_2level_size50[44]->in[10] density = 0, probability=0.*****
Vmux_2level_size50[44]->in[10] mux_2level_size50[44]->in[10] 0
+  0
***** Signal mux_2level_size50[44]->in[11] density = 0, probability=0.*****
Vmux_2level_size50[44]->in[11] mux_2level_size50[44]->in[11] 0
+  0
***** Signal mux_2level_size50[44]->in[12] density = 0, probability=0.*****
Vmux_2level_size50[44]->in[12] mux_2level_size50[44]->in[12] 0
+  0
***** Signal mux_2level_size50[44]->in[13] density = 0, probability=0.*****
Vmux_2level_size50[44]->in[13] mux_2level_size50[44]->in[13] 0
+  0
***** Signal mux_2level_size50[44]->in[14] density = 0, probability=0.*****
Vmux_2level_size50[44]->in[14] mux_2level_size50[44]->in[14] 0
+  0
***** Signal mux_2level_size50[44]->in[15] density = 0, probability=0.*****
Vmux_2level_size50[44]->in[15] mux_2level_size50[44]->in[15] 0
+  0
***** Signal mux_2level_size50[44]->in[16] density = 0, probability=0.*****
Vmux_2level_size50[44]->in[16] mux_2level_size50[44]->in[16] 0
+  0
***** Signal mux_2level_size50[44]->in[17] density = 0, probability=0.*****
Vmux_2level_size50[44]->in[17] mux_2level_size50[44]->in[17] 0
+  0
***** Signal mux_2level_size50[44]->in[18] density = 0, probability=0.*****
Vmux_2level_size50[44]->in[18] mux_2level_size50[44]->in[18] 0
+  0
***** Signal mux_2level_size50[44]->in[19] density = 0, probability=0.*****
Vmux_2level_size50[44]->in[19] mux_2level_size50[44]->in[19] 0
+  0
***** Signal mux_2level_size50[44]->in[20] density = 0, probability=0.*****
Vmux_2level_size50[44]->in[20] mux_2level_size50[44]->in[20] 0
+  0
***** Signal mux_2level_size50[44]->in[21] density = 0, probability=0.*****
Vmux_2level_size50[44]->in[21] mux_2level_size50[44]->in[21] 0
+  0
***** Signal mux_2level_size50[44]->in[22] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[44]->in[22] mux_2level_size50[44]->in[22] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[44]->in[23] density = 0, probability=0.*****
Vmux_2level_size50[44]->in[23] mux_2level_size50[44]->in[23] 0
+  0
***** Signal mux_2level_size50[44]->in[24] density = 0, probability=0.*****
Vmux_2level_size50[44]->in[24] mux_2level_size50[44]->in[24] 0
+  0
***** Signal mux_2level_size50[44]->in[25] density = 0, probability=0.*****
Vmux_2level_size50[44]->in[25] mux_2level_size50[44]->in[25] 0
+  0
***** Signal mux_2level_size50[44]->in[26] density = 0, probability=0.*****
Vmux_2level_size50[44]->in[26] mux_2level_size50[44]->in[26] 0
+  0
***** Signal mux_2level_size50[44]->in[27] density = 0, probability=0.*****
Vmux_2level_size50[44]->in[27] mux_2level_size50[44]->in[27] 0
+  0
***** Signal mux_2level_size50[44]->in[28] density = 0, probability=0.*****
Vmux_2level_size50[44]->in[28] mux_2level_size50[44]->in[28] 0
+  0
***** Signal mux_2level_size50[44]->in[29] density = 0, probability=0.*****
Vmux_2level_size50[44]->in[29] mux_2level_size50[44]->in[29] 0
+  0
***** Signal mux_2level_size50[44]->in[30] density = 0, probability=0.*****
Vmux_2level_size50[44]->in[30] mux_2level_size50[44]->in[30] 0
+  0
***** Signal mux_2level_size50[44]->in[31] density = 0, probability=0.*****
Vmux_2level_size50[44]->in[31] mux_2level_size50[44]->in[31] 0
+  0
***** Signal mux_2level_size50[44]->in[32] density = 0, probability=0.*****
Vmux_2level_size50[44]->in[32] mux_2level_size50[44]->in[32] 0
+  0
***** Signal mux_2level_size50[44]->in[33] density = 0, probability=0.*****
Vmux_2level_size50[44]->in[33] mux_2level_size50[44]->in[33] 0
+  0
***** Signal mux_2level_size50[44]->in[34] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[44]->in[34] mux_2level_size50[44]->in[34] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[44]->in[35] density = 0, probability=0.*****
Vmux_2level_size50[44]->in[35] mux_2level_size50[44]->in[35] 0
+  0
***** Signal mux_2level_size50[44]->in[36] density = 0, probability=0.*****
Vmux_2level_size50[44]->in[36] mux_2level_size50[44]->in[36] 0
+  0
***** Signal mux_2level_size50[44]->in[37] density = 0, probability=0.*****
Vmux_2level_size50[44]->in[37] mux_2level_size50[44]->in[37] 0
+  0
***** Signal mux_2level_size50[44]->in[38] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[44]->in[38] mux_2level_size50[44]->in[38] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[44]->in[39] density = 0, probability=0.*****
Vmux_2level_size50[44]->in[39] mux_2level_size50[44]->in[39] 0
+  0
***** Signal mux_2level_size50[44]->in[40] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[44]->in[40] mux_2level_size50[44]->in[40] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[44]->in[41] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[44]->in[41] mux_2level_size50[44]->in[41] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[44]->in[42] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[44]->in[42] mux_2level_size50[44]->in[42] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[44]->in[43] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[44]->in[43] mux_2level_size50[44]->in[43] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[44]->in[44] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[44]->in[44] mux_2level_size50[44]->in[44] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[44]->in[45] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[44]->in[45] mux_2level_size50[44]->in[45] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[44]->in[46] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[44]->in[46] mux_2level_size50[44]->in[46] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[44]->in[47] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[44]->in[47] mux_2level_size50[44]->in[47] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[44]->in[48] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[44]->in[48] mux_2level_size50[44]->in[48] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[44]->in[49] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[44]->in[49] mux_2level_size50[44]->in[49] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
Vgvdd_mux_2level_size50[44] gvdd_mux_2level_size50[44] 0 vsp
***** Measurements *****
***** Rise delay *****
.meas tran delay_rise_idle_mux50[44]_in[2]_crossbar trig v(mux_2level_size50[44]->in[0]) val='input_thres_pct_rise*vsp' rise=1 td='clock_period'
+          targ v(mux_2level_size50[44]->out) val='output_thres_pct_rise*vsp' rise=1 td='clock_period'
***** Fall delay *****
.meas tran delay_fall_idle_mux50[44]_in[2]_crossbar trig v(mux_2level_size50[44]->in[0]) val='input_thres_pct_fall*vsp' fall=1 td='clock_period'
+          targ v(mux_2level_size50[44]->out) val='output_thres_pct_fall*vsp' fall=1 td='clock_period'
***** Rise timing period *****
.meas start_rise_idle_mux50[44]_in[2]_crossbar when v(mux_2level_size50[44]->in[0])='slew_lower_thres_pct_rise*vsp' rise=1 td='clock_period'
.meas tran switch_rise_idle_mux50[44]_in[2]_crossbar trig v(mux_2level_size50[44]->in[0]) val='slew_lower_thres_pct_rise*vsp' rise=1 td='clock_period'
+          targ v(mux_2level_size50[44]->out) val='slew_upper_thres_pct_rise*vsp' rise=1 td='clock_period'
***** Fall timing period *****
.meas start_fall_idle_mux50[44]_in[2]_crossbar when v(mux_2level_size50[44]->in[0])='slew_lower_thres_pct_fall*vsp' fall=1 td='clock_period'
.meas tran switch_fall_idle_mux50[44]_in[2]_crossbar trig v(mux_2level_size50[44]->in[0]) val='slew_lower_thres_pct_fall*vsp' fall=1 td='clock_period'
+          targ v(mux_2level_size50[44]->out) val='slew_upper_thres_pct_fall*vsp' fall=1 td='clock_period'
***** Leakage Power Measurement *****
.meas tran mux_2level_size50[44]_leakage_power avg p(Vgvdd_mux_2level_size50[44]) from=0 to='clock_period'
.meas tran leakage_idle_mux50[44]_in[2]_crossbar param='mux_2level_size50[44]_leakage_power'
***** Dynamic Power Measurement *****
.meas tran mux_2level_size50[44]_dynamic_power avg p(Vgvdd_mux_2level_size50[44]) from='clock_period' to='6*clock_period'
.meas tran mux_2level_size50[44]_energy_per_cycle param='mux_2level_size50[44]_dynamic_power*clock_period'
.meas tran dynamic_power_idle_mux50[44]_in[2]_crossbar  param='mux_2level_size50[44]_dynamic_power'
.meas tran energy_per_cycle_idle_mux50[44]_in[2]_crossbar  param='dynamic_power_idle_mux50[44]_in[2]_crossbar*clock_period'
.meas tran dynamic_rise_idle_mux50[44]_in[2]_crossbar avg p(Vgvdd_mux_2level_size50[44]) from='start_rise_idle_mux50[44]_in[2]_crossbar' to='start_rise_idle_mux50[44]_in[2]_crossbar+switch_rise_idle_mux50[44]_in[2]_crossbar'
.meas tran dynamic_fall_idle_mux50[44]_in[2]_crossbar avg p(Vgvdd_mux_2level_size50[44]) from='start_fall_idle_mux50[44]_in[2]_crossbar' to='start_fall_idle_mux50[44]_in[2]_crossbar+switch_fall_idle_mux50[44]_in[2]_crossbar'
.meas tran sum_leakage_power_mux[0to44]
+          param='sum_leakage_power_mux[0to43]+leakage_idle_mux50[44]_in[2]_crossbar'
.meas tran sum_energy_per_cycle_mux[0to44]
+          param='sum_energy_per_cycle_mux[0to43]+energy_per_cycle_idle_mux50[44]_in[2]_crossbar'
Xload_inv[44]_no0 mux_2level_size50[44]->out mux_2level_size50[44]->out_out[0] gvdd_load 0 inv size=5
.meas tran sum_leakage_power_pb_mux[0to44]
+          param='sum_leakage_power_pb_mux[0to43]+leakage_idle_mux50[44]_in[2]_crossbar'
.meas tran sum_energy_per_cycle_pb_mux[0to44]
+          param='sum_energy_per_cycle_pb_mux[0to43]+energy_per_cycle_idle_mux50[44]_in[2]_crossbar'
Xmux_2level_size50[45] mux_2level_size50[45]->in[0] mux_2level_size50[45]->in[1] mux_2level_size50[45]->in[2] mux_2level_size50[45]->in[3] mux_2level_size50[45]->in[4] mux_2level_size50[45]->in[5] mux_2level_size50[45]->in[6] mux_2level_size50[45]->in[7] mux_2level_size50[45]->in[8] mux_2level_size50[45]->in[9] mux_2level_size50[45]->in[10] mux_2level_size50[45]->in[11] mux_2level_size50[45]->in[12] mux_2level_size50[45]->in[13] mux_2level_size50[45]->in[14] mux_2level_size50[45]->in[15] mux_2level_size50[45]->in[16] mux_2level_size50[45]->in[17] mux_2level_size50[45]->in[18] mux_2level_size50[45]->in[19] mux_2level_size50[45]->in[20] mux_2level_size50[45]->in[21] mux_2level_size50[45]->in[22] mux_2level_size50[45]->in[23] mux_2level_size50[45]->in[24] mux_2level_size50[45]->in[25] mux_2level_size50[45]->in[26] mux_2level_size50[45]->in[27] mux_2level_size50[45]->in[28] mux_2level_size50[45]->in[29] mux_2level_size50[45]->in[30] mux_2level_size50[45]->in[31] mux_2level_size50[45]->in[32] mux_2level_size50[45]->in[33] mux_2level_size50[45]->in[34] mux_2level_size50[45]->in[35] mux_2level_size50[45]->in[36] mux_2level_size50[45]->in[37] mux_2level_size50[45]->in[38] mux_2level_size50[45]->in[39] mux_2level_size50[45]->in[40] mux_2level_size50[45]->in[41] mux_2level_size50[45]->in[42] mux_2level_size50[45]->in[43] mux_2level_size50[45]->in[44] mux_2level_size50[45]->in[45] mux_2level_size50[45]->in[46] mux_2level_size50[45]->in[47] mux_2level_size50[45]->in[48] mux_2level_size50[45]->in[49] mux_2level_size50[45]->out sram[720]->outb sram[720]->out sram[721]->out sram[721]->outb sram[722]->out sram[722]->outb sram[723]->out sram[723]->outb sram[724]->out sram[724]->outb sram[725]->out sram[725]->outb sram[726]->out sram[726]->outb sram[727]->out sram[727]->outb sram[728]->outb sram[728]->out sram[729]->out sram[729]->outb sram[730]->out sram[730]->outb sram[731]->out sram[731]->outb sram[732]->out sram[732]->outb sram[733]->out sram[733]->outb sram[734]->out sram[734]->outb sram[735]->out sram[735]->outb gvdd_mux_2level_size50[45] 0 mux_2level_size50
***** SRAM bits for MUX[45], level=2, select_path_id=0. *****
*****1000000010000000*****
Xsram[720] sram->in sram[720]->out sram[720]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[720]->out) 0
.nodeset V(sram[720]->outb) vsp
Xsram[721] sram->in sram[721]->out sram[721]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[721]->out) 0
.nodeset V(sram[721]->outb) vsp
Xsram[722] sram->in sram[722]->out sram[722]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[722]->out) 0
.nodeset V(sram[722]->outb) vsp
Xsram[723] sram->in sram[723]->out sram[723]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[723]->out) 0
.nodeset V(sram[723]->outb) vsp
Xsram[724] sram->in sram[724]->out sram[724]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[724]->out) 0
.nodeset V(sram[724]->outb) vsp
Xsram[725] sram->in sram[725]->out sram[725]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[725]->out) 0
.nodeset V(sram[725]->outb) vsp
Xsram[726] sram->in sram[726]->out sram[726]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[726]->out) 0
.nodeset V(sram[726]->outb) vsp
Xsram[727] sram->in sram[727]->out sram[727]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[727]->out) 0
.nodeset V(sram[727]->outb) vsp
Xsram[728] sram->in sram[728]->out sram[728]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[728]->out) 0
.nodeset V(sram[728]->outb) vsp
Xsram[729] sram->in sram[729]->out sram[729]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[729]->out) 0
.nodeset V(sram[729]->outb) vsp
Xsram[730] sram->in sram[730]->out sram[730]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[730]->out) 0
.nodeset V(sram[730]->outb) vsp
Xsram[731] sram->in sram[731]->out sram[731]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[731]->out) 0
.nodeset V(sram[731]->outb) vsp
Xsram[732] sram->in sram[732]->out sram[732]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[732]->out) 0
.nodeset V(sram[732]->outb) vsp
Xsram[733] sram->in sram[733]->out sram[733]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[733]->out) 0
.nodeset V(sram[733]->outb) vsp
Xsram[734] sram->in sram[734]->out sram[734]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[734]->out) 0
.nodeset V(sram[734]->outb) vsp
Xsram[735] sram->in sram[735]->out sram[735]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[735]->out) 0
.nodeset V(sram[735]->outb) vsp
***** Signal mux_2level_size50[45]->in[0] density = 0, probability=0.*****
Vmux_2level_size50[45]->in[0] mux_2level_size50[45]->in[0] 0
+  0
***** Signal mux_2level_size50[45]->in[1] density = 0, probability=0.*****
Vmux_2level_size50[45]->in[1] mux_2level_size50[45]->in[1] 0
+  0
***** Signal mux_2level_size50[45]->in[2] density = 0, probability=0.*****
Vmux_2level_size50[45]->in[2] mux_2level_size50[45]->in[2] 0
+  0
***** Signal mux_2level_size50[45]->in[3] density = 0, probability=0.*****
Vmux_2level_size50[45]->in[3] mux_2level_size50[45]->in[3] 0
+  0
***** Signal mux_2level_size50[45]->in[4] density = 0, probability=0.*****
Vmux_2level_size50[45]->in[4] mux_2level_size50[45]->in[4] 0
+  0
***** Signal mux_2level_size50[45]->in[5] density = 0, probability=0.*****
Vmux_2level_size50[45]->in[5] mux_2level_size50[45]->in[5] 0
+  0
***** Signal mux_2level_size50[45]->in[6] density = 0, probability=0.*****
Vmux_2level_size50[45]->in[6] mux_2level_size50[45]->in[6] 0
+  0
***** Signal mux_2level_size50[45]->in[7] density = 0, probability=0.*****
Vmux_2level_size50[45]->in[7] mux_2level_size50[45]->in[7] 0
+  0
***** Signal mux_2level_size50[45]->in[8] density = 0, probability=0.*****
Vmux_2level_size50[45]->in[8] mux_2level_size50[45]->in[8] 0
+  0
***** Signal mux_2level_size50[45]->in[9] density = 0, probability=0.*****
Vmux_2level_size50[45]->in[9] mux_2level_size50[45]->in[9] 0
+  0
***** Signal mux_2level_size50[45]->in[10] density = 0, probability=0.*****
Vmux_2level_size50[45]->in[10] mux_2level_size50[45]->in[10] 0
+  0
***** Signal mux_2level_size50[45]->in[11] density = 0, probability=0.*****
Vmux_2level_size50[45]->in[11] mux_2level_size50[45]->in[11] 0
+  0
***** Signal mux_2level_size50[45]->in[12] density = 0, probability=0.*****
Vmux_2level_size50[45]->in[12] mux_2level_size50[45]->in[12] 0
+  0
***** Signal mux_2level_size50[45]->in[13] density = 0, probability=0.*****
Vmux_2level_size50[45]->in[13] mux_2level_size50[45]->in[13] 0
+  0
***** Signal mux_2level_size50[45]->in[14] density = 0, probability=0.*****
Vmux_2level_size50[45]->in[14] mux_2level_size50[45]->in[14] 0
+  0
***** Signal mux_2level_size50[45]->in[15] density = 0, probability=0.*****
Vmux_2level_size50[45]->in[15] mux_2level_size50[45]->in[15] 0
+  0
***** Signal mux_2level_size50[45]->in[16] density = 0, probability=0.*****
Vmux_2level_size50[45]->in[16] mux_2level_size50[45]->in[16] 0
+  0
***** Signal mux_2level_size50[45]->in[17] density = 0, probability=0.*****
Vmux_2level_size50[45]->in[17] mux_2level_size50[45]->in[17] 0
+  0
***** Signal mux_2level_size50[45]->in[18] density = 0, probability=0.*****
Vmux_2level_size50[45]->in[18] mux_2level_size50[45]->in[18] 0
+  0
***** Signal mux_2level_size50[45]->in[19] density = 0, probability=0.*****
Vmux_2level_size50[45]->in[19] mux_2level_size50[45]->in[19] 0
+  0
***** Signal mux_2level_size50[45]->in[20] density = 0, probability=0.*****
Vmux_2level_size50[45]->in[20] mux_2level_size50[45]->in[20] 0
+  0
***** Signal mux_2level_size50[45]->in[21] density = 0, probability=0.*****
Vmux_2level_size50[45]->in[21] mux_2level_size50[45]->in[21] 0
+  0
***** Signal mux_2level_size50[45]->in[22] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[45]->in[22] mux_2level_size50[45]->in[22] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[45]->in[23] density = 0, probability=0.*****
Vmux_2level_size50[45]->in[23] mux_2level_size50[45]->in[23] 0
+  0
***** Signal mux_2level_size50[45]->in[24] density = 0, probability=0.*****
Vmux_2level_size50[45]->in[24] mux_2level_size50[45]->in[24] 0
+  0
***** Signal mux_2level_size50[45]->in[25] density = 0, probability=0.*****
Vmux_2level_size50[45]->in[25] mux_2level_size50[45]->in[25] 0
+  0
***** Signal mux_2level_size50[45]->in[26] density = 0, probability=0.*****
Vmux_2level_size50[45]->in[26] mux_2level_size50[45]->in[26] 0
+  0
***** Signal mux_2level_size50[45]->in[27] density = 0, probability=0.*****
Vmux_2level_size50[45]->in[27] mux_2level_size50[45]->in[27] 0
+  0
***** Signal mux_2level_size50[45]->in[28] density = 0, probability=0.*****
Vmux_2level_size50[45]->in[28] mux_2level_size50[45]->in[28] 0
+  0
***** Signal mux_2level_size50[45]->in[29] density = 0, probability=0.*****
Vmux_2level_size50[45]->in[29] mux_2level_size50[45]->in[29] 0
+  0
***** Signal mux_2level_size50[45]->in[30] density = 0, probability=0.*****
Vmux_2level_size50[45]->in[30] mux_2level_size50[45]->in[30] 0
+  0
***** Signal mux_2level_size50[45]->in[31] density = 0, probability=0.*****
Vmux_2level_size50[45]->in[31] mux_2level_size50[45]->in[31] 0
+  0
***** Signal mux_2level_size50[45]->in[32] density = 0, probability=0.*****
Vmux_2level_size50[45]->in[32] mux_2level_size50[45]->in[32] 0
+  0
***** Signal mux_2level_size50[45]->in[33] density = 0, probability=0.*****
Vmux_2level_size50[45]->in[33] mux_2level_size50[45]->in[33] 0
+  0
***** Signal mux_2level_size50[45]->in[34] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[45]->in[34] mux_2level_size50[45]->in[34] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[45]->in[35] density = 0, probability=0.*****
Vmux_2level_size50[45]->in[35] mux_2level_size50[45]->in[35] 0
+  0
***** Signal mux_2level_size50[45]->in[36] density = 0, probability=0.*****
Vmux_2level_size50[45]->in[36] mux_2level_size50[45]->in[36] 0
+  0
***** Signal mux_2level_size50[45]->in[37] density = 0, probability=0.*****
Vmux_2level_size50[45]->in[37] mux_2level_size50[45]->in[37] 0
+  0
***** Signal mux_2level_size50[45]->in[38] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[45]->in[38] mux_2level_size50[45]->in[38] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[45]->in[39] density = 0, probability=0.*****
Vmux_2level_size50[45]->in[39] mux_2level_size50[45]->in[39] 0
+  0
***** Signal mux_2level_size50[45]->in[40] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[45]->in[40] mux_2level_size50[45]->in[40] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[45]->in[41] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[45]->in[41] mux_2level_size50[45]->in[41] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[45]->in[42] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[45]->in[42] mux_2level_size50[45]->in[42] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[45]->in[43] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[45]->in[43] mux_2level_size50[45]->in[43] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[45]->in[44] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[45]->in[44] mux_2level_size50[45]->in[44] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[45]->in[45] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[45]->in[45] mux_2level_size50[45]->in[45] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[45]->in[46] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[45]->in[46] mux_2level_size50[45]->in[46] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[45]->in[47] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[45]->in[47] mux_2level_size50[45]->in[47] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[45]->in[48] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[45]->in[48] mux_2level_size50[45]->in[48] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[45]->in[49] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[45]->in[49] mux_2level_size50[45]->in[49] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
Vgvdd_mux_2level_size50[45] gvdd_mux_2level_size50[45] 0 vsp
***** Measurements *****
***** Rise delay *****
.meas tran delay_rise_idle_mux50[45]_in[3]_crossbar trig v(mux_2level_size50[45]->in[0]) val='input_thres_pct_rise*vsp' rise=1 td='clock_period'
+          targ v(mux_2level_size50[45]->out) val='output_thres_pct_rise*vsp' rise=1 td='clock_period'
***** Fall delay *****
.meas tran delay_fall_idle_mux50[45]_in[3]_crossbar trig v(mux_2level_size50[45]->in[0]) val='input_thres_pct_fall*vsp' fall=1 td='clock_period'
+          targ v(mux_2level_size50[45]->out) val='output_thres_pct_fall*vsp' fall=1 td='clock_period'
***** Rise timing period *****
.meas start_rise_idle_mux50[45]_in[3]_crossbar when v(mux_2level_size50[45]->in[0])='slew_lower_thres_pct_rise*vsp' rise=1 td='clock_period'
.meas tran switch_rise_idle_mux50[45]_in[3]_crossbar trig v(mux_2level_size50[45]->in[0]) val='slew_lower_thres_pct_rise*vsp' rise=1 td='clock_period'
+          targ v(mux_2level_size50[45]->out) val='slew_upper_thres_pct_rise*vsp' rise=1 td='clock_period'
***** Fall timing period *****
.meas start_fall_idle_mux50[45]_in[3]_crossbar when v(mux_2level_size50[45]->in[0])='slew_lower_thres_pct_fall*vsp' fall=1 td='clock_period'
.meas tran switch_fall_idle_mux50[45]_in[3]_crossbar trig v(mux_2level_size50[45]->in[0]) val='slew_lower_thres_pct_fall*vsp' fall=1 td='clock_period'
+          targ v(mux_2level_size50[45]->out) val='slew_upper_thres_pct_fall*vsp' fall=1 td='clock_period'
***** Leakage Power Measurement *****
.meas tran mux_2level_size50[45]_leakage_power avg p(Vgvdd_mux_2level_size50[45]) from=0 to='clock_period'
.meas tran leakage_idle_mux50[45]_in[3]_crossbar param='mux_2level_size50[45]_leakage_power'
***** Dynamic Power Measurement *****
.meas tran mux_2level_size50[45]_dynamic_power avg p(Vgvdd_mux_2level_size50[45]) from='clock_period' to='6*clock_period'
.meas tran mux_2level_size50[45]_energy_per_cycle param='mux_2level_size50[45]_dynamic_power*clock_period'
.meas tran dynamic_power_idle_mux50[45]_in[3]_crossbar  param='mux_2level_size50[45]_dynamic_power'
.meas tran energy_per_cycle_idle_mux50[45]_in[3]_crossbar  param='dynamic_power_idle_mux50[45]_in[3]_crossbar*clock_period'
.meas tran dynamic_rise_idle_mux50[45]_in[3]_crossbar avg p(Vgvdd_mux_2level_size50[45]) from='start_rise_idle_mux50[45]_in[3]_crossbar' to='start_rise_idle_mux50[45]_in[3]_crossbar+switch_rise_idle_mux50[45]_in[3]_crossbar'
.meas tran dynamic_fall_idle_mux50[45]_in[3]_crossbar avg p(Vgvdd_mux_2level_size50[45]) from='start_fall_idle_mux50[45]_in[3]_crossbar' to='start_fall_idle_mux50[45]_in[3]_crossbar+switch_fall_idle_mux50[45]_in[3]_crossbar'
.meas tran sum_leakage_power_mux[0to45]
+          param='sum_leakage_power_mux[0to44]+leakage_idle_mux50[45]_in[3]_crossbar'
.meas tran sum_energy_per_cycle_mux[0to45]
+          param='sum_energy_per_cycle_mux[0to44]+energy_per_cycle_idle_mux50[45]_in[3]_crossbar'
Xload_inv[45]_no0 mux_2level_size50[45]->out mux_2level_size50[45]->out_out[0] gvdd_load 0 inv size=5
.meas tran sum_leakage_power_pb_mux[0to45]
+          param='sum_leakage_power_pb_mux[0to44]+leakage_idle_mux50[45]_in[3]_crossbar'
.meas tran sum_energy_per_cycle_pb_mux[0to45]
+          param='sum_energy_per_cycle_pb_mux[0to44]+energy_per_cycle_idle_mux50[45]_in[3]_crossbar'
Xmux_2level_size50[46] mux_2level_size50[46]->in[0] mux_2level_size50[46]->in[1] mux_2level_size50[46]->in[2] mux_2level_size50[46]->in[3] mux_2level_size50[46]->in[4] mux_2level_size50[46]->in[5] mux_2level_size50[46]->in[6] mux_2level_size50[46]->in[7] mux_2level_size50[46]->in[8] mux_2level_size50[46]->in[9] mux_2level_size50[46]->in[10] mux_2level_size50[46]->in[11] mux_2level_size50[46]->in[12] mux_2level_size50[46]->in[13] mux_2level_size50[46]->in[14] mux_2level_size50[46]->in[15] mux_2level_size50[46]->in[16] mux_2level_size50[46]->in[17] mux_2level_size50[46]->in[18] mux_2level_size50[46]->in[19] mux_2level_size50[46]->in[20] mux_2level_size50[46]->in[21] mux_2level_size50[46]->in[22] mux_2level_size50[46]->in[23] mux_2level_size50[46]->in[24] mux_2level_size50[46]->in[25] mux_2level_size50[46]->in[26] mux_2level_size50[46]->in[27] mux_2level_size50[46]->in[28] mux_2level_size50[46]->in[29] mux_2level_size50[46]->in[30] mux_2level_size50[46]->in[31] mux_2level_size50[46]->in[32] mux_2level_size50[46]->in[33] mux_2level_size50[46]->in[34] mux_2level_size50[46]->in[35] mux_2level_size50[46]->in[36] mux_2level_size50[46]->in[37] mux_2level_size50[46]->in[38] mux_2level_size50[46]->in[39] mux_2level_size50[46]->in[40] mux_2level_size50[46]->in[41] mux_2level_size50[46]->in[42] mux_2level_size50[46]->in[43] mux_2level_size50[46]->in[44] mux_2level_size50[46]->in[45] mux_2level_size50[46]->in[46] mux_2level_size50[46]->in[47] mux_2level_size50[46]->in[48] mux_2level_size50[46]->in[49] mux_2level_size50[46]->out sram[736]->outb sram[736]->out sram[737]->out sram[737]->outb sram[738]->out sram[738]->outb sram[739]->out sram[739]->outb sram[740]->out sram[740]->outb sram[741]->out sram[741]->outb sram[742]->out sram[742]->outb sram[743]->out sram[743]->outb sram[744]->outb sram[744]->out sram[745]->out sram[745]->outb sram[746]->out sram[746]->outb sram[747]->out sram[747]->outb sram[748]->out sram[748]->outb sram[749]->out sram[749]->outb sram[750]->out sram[750]->outb sram[751]->out sram[751]->outb gvdd_mux_2level_size50[46] 0 mux_2level_size50
***** SRAM bits for MUX[46], level=2, select_path_id=0. *****
*****1000000010000000*****
Xsram[736] sram->in sram[736]->out sram[736]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[736]->out) 0
.nodeset V(sram[736]->outb) vsp
Xsram[737] sram->in sram[737]->out sram[737]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[737]->out) 0
.nodeset V(sram[737]->outb) vsp
Xsram[738] sram->in sram[738]->out sram[738]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[738]->out) 0
.nodeset V(sram[738]->outb) vsp
Xsram[739] sram->in sram[739]->out sram[739]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[739]->out) 0
.nodeset V(sram[739]->outb) vsp
Xsram[740] sram->in sram[740]->out sram[740]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[740]->out) 0
.nodeset V(sram[740]->outb) vsp
Xsram[741] sram->in sram[741]->out sram[741]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[741]->out) 0
.nodeset V(sram[741]->outb) vsp
Xsram[742] sram->in sram[742]->out sram[742]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[742]->out) 0
.nodeset V(sram[742]->outb) vsp
Xsram[743] sram->in sram[743]->out sram[743]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[743]->out) 0
.nodeset V(sram[743]->outb) vsp
Xsram[744] sram->in sram[744]->out sram[744]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[744]->out) 0
.nodeset V(sram[744]->outb) vsp
Xsram[745] sram->in sram[745]->out sram[745]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[745]->out) 0
.nodeset V(sram[745]->outb) vsp
Xsram[746] sram->in sram[746]->out sram[746]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[746]->out) 0
.nodeset V(sram[746]->outb) vsp
Xsram[747] sram->in sram[747]->out sram[747]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[747]->out) 0
.nodeset V(sram[747]->outb) vsp
Xsram[748] sram->in sram[748]->out sram[748]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[748]->out) 0
.nodeset V(sram[748]->outb) vsp
Xsram[749] sram->in sram[749]->out sram[749]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[749]->out) 0
.nodeset V(sram[749]->outb) vsp
Xsram[750] sram->in sram[750]->out sram[750]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[750]->out) 0
.nodeset V(sram[750]->outb) vsp
Xsram[751] sram->in sram[751]->out sram[751]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[751]->out) 0
.nodeset V(sram[751]->outb) vsp
***** Signal mux_2level_size50[46]->in[0] density = 0, probability=0.*****
Vmux_2level_size50[46]->in[0] mux_2level_size50[46]->in[0] 0
+  0
***** Signal mux_2level_size50[46]->in[1] density = 0, probability=0.*****
Vmux_2level_size50[46]->in[1] mux_2level_size50[46]->in[1] 0
+  0
***** Signal mux_2level_size50[46]->in[2] density = 0, probability=0.*****
Vmux_2level_size50[46]->in[2] mux_2level_size50[46]->in[2] 0
+  0
***** Signal mux_2level_size50[46]->in[3] density = 0, probability=0.*****
Vmux_2level_size50[46]->in[3] mux_2level_size50[46]->in[3] 0
+  0
***** Signal mux_2level_size50[46]->in[4] density = 0, probability=0.*****
Vmux_2level_size50[46]->in[4] mux_2level_size50[46]->in[4] 0
+  0
***** Signal mux_2level_size50[46]->in[5] density = 0, probability=0.*****
Vmux_2level_size50[46]->in[5] mux_2level_size50[46]->in[5] 0
+  0
***** Signal mux_2level_size50[46]->in[6] density = 0, probability=0.*****
Vmux_2level_size50[46]->in[6] mux_2level_size50[46]->in[6] 0
+  0
***** Signal mux_2level_size50[46]->in[7] density = 0, probability=0.*****
Vmux_2level_size50[46]->in[7] mux_2level_size50[46]->in[7] 0
+  0
***** Signal mux_2level_size50[46]->in[8] density = 0, probability=0.*****
Vmux_2level_size50[46]->in[8] mux_2level_size50[46]->in[8] 0
+  0
***** Signal mux_2level_size50[46]->in[9] density = 0, probability=0.*****
Vmux_2level_size50[46]->in[9] mux_2level_size50[46]->in[9] 0
+  0
***** Signal mux_2level_size50[46]->in[10] density = 0, probability=0.*****
Vmux_2level_size50[46]->in[10] mux_2level_size50[46]->in[10] 0
+  0
***** Signal mux_2level_size50[46]->in[11] density = 0, probability=0.*****
Vmux_2level_size50[46]->in[11] mux_2level_size50[46]->in[11] 0
+  0
***** Signal mux_2level_size50[46]->in[12] density = 0, probability=0.*****
Vmux_2level_size50[46]->in[12] mux_2level_size50[46]->in[12] 0
+  0
***** Signal mux_2level_size50[46]->in[13] density = 0, probability=0.*****
Vmux_2level_size50[46]->in[13] mux_2level_size50[46]->in[13] 0
+  0
***** Signal mux_2level_size50[46]->in[14] density = 0, probability=0.*****
Vmux_2level_size50[46]->in[14] mux_2level_size50[46]->in[14] 0
+  0
***** Signal mux_2level_size50[46]->in[15] density = 0, probability=0.*****
Vmux_2level_size50[46]->in[15] mux_2level_size50[46]->in[15] 0
+  0
***** Signal mux_2level_size50[46]->in[16] density = 0, probability=0.*****
Vmux_2level_size50[46]->in[16] mux_2level_size50[46]->in[16] 0
+  0
***** Signal mux_2level_size50[46]->in[17] density = 0, probability=0.*****
Vmux_2level_size50[46]->in[17] mux_2level_size50[46]->in[17] 0
+  0
***** Signal mux_2level_size50[46]->in[18] density = 0, probability=0.*****
Vmux_2level_size50[46]->in[18] mux_2level_size50[46]->in[18] 0
+  0
***** Signal mux_2level_size50[46]->in[19] density = 0, probability=0.*****
Vmux_2level_size50[46]->in[19] mux_2level_size50[46]->in[19] 0
+  0
***** Signal mux_2level_size50[46]->in[20] density = 0, probability=0.*****
Vmux_2level_size50[46]->in[20] mux_2level_size50[46]->in[20] 0
+  0
***** Signal mux_2level_size50[46]->in[21] density = 0, probability=0.*****
Vmux_2level_size50[46]->in[21] mux_2level_size50[46]->in[21] 0
+  0
***** Signal mux_2level_size50[46]->in[22] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[46]->in[22] mux_2level_size50[46]->in[22] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[46]->in[23] density = 0, probability=0.*****
Vmux_2level_size50[46]->in[23] mux_2level_size50[46]->in[23] 0
+  0
***** Signal mux_2level_size50[46]->in[24] density = 0, probability=0.*****
Vmux_2level_size50[46]->in[24] mux_2level_size50[46]->in[24] 0
+  0
***** Signal mux_2level_size50[46]->in[25] density = 0, probability=0.*****
Vmux_2level_size50[46]->in[25] mux_2level_size50[46]->in[25] 0
+  0
***** Signal mux_2level_size50[46]->in[26] density = 0, probability=0.*****
Vmux_2level_size50[46]->in[26] mux_2level_size50[46]->in[26] 0
+  0
***** Signal mux_2level_size50[46]->in[27] density = 0, probability=0.*****
Vmux_2level_size50[46]->in[27] mux_2level_size50[46]->in[27] 0
+  0
***** Signal mux_2level_size50[46]->in[28] density = 0, probability=0.*****
Vmux_2level_size50[46]->in[28] mux_2level_size50[46]->in[28] 0
+  0
***** Signal mux_2level_size50[46]->in[29] density = 0, probability=0.*****
Vmux_2level_size50[46]->in[29] mux_2level_size50[46]->in[29] 0
+  0
***** Signal mux_2level_size50[46]->in[30] density = 0, probability=0.*****
Vmux_2level_size50[46]->in[30] mux_2level_size50[46]->in[30] 0
+  0
***** Signal mux_2level_size50[46]->in[31] density = 0, probability=0.*****
Vmux_2level_size50[46]->in[31] mux_2level_size50[46]->in[31] 0
+  0
***** Signal mux_2level_size50[46]->in[32] density = 0, probability=0.*****
Vmux_2level_size50[46]->in[32] mux_2level_size50[46]->in[32] 0
+  0
***** Signal mux_2level_size50[46]->in[33] density = 0, probability=0.*****
Vmux_2level_size50[46]->in[33] mux_2level_size50[46]->in[33] 0
+  0
***** Signal mux_2level_size50[46]->in[34] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[46]->in[34] mux_2level_size50[46]->in[34] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[46]->in[35] density = 0, probability=0.*****
Vmux_2level_size50[46]->in[35] mux_2level_size50[46]->in[35] 0
+  0
***** Signal mux_2level_size50[46]->in[36] density = 0, probability=0.*****
Vmux_2level_size50[46]->in[36] mux_2level_size50[46]->in[36] 0
+  0
***** Signal mux_2level_size50[46]->in[37] density = 0, probability=0.*****
Vmux_2level_size50[46]->in[37] mux_2level_size50[46]->in[37] 0
+  0
***** Signal mux_2level_size50[46]->in[38] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[46]->in[38] mux_2level_size50[46]->in[38] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[46]->in[39] density = 0, probability=0.*****
Vmux_2level_size50[46]->in[39] mux_2level_size50[46]->in[39] 0
+  0
***** Signal mux_2level_size50[46]->in[40] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[46]->in[40] mux_2level_size50[46]->in[40] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[46]->in[41] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[46]->in[41] mux_2level_size50[46]->in[41] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[46]->in[42] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[46]->in[42] mux_2level_size50[46]->in[42] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[46]->in[43] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[46]->in[43] mux_2level_size50[46]->in[43] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[46]->in[44] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[46]->in[44] mux_2level_size50[46]->in[44] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[46]->in[45] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[46]->in[45] mux_2level_size50[46]->in[45] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[46]->in[46] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[46]->in[46] mux_2level_size50[46]->in[46] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[46]->in[47] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[46]->in[47] mux_2level_size50[46]->in[47] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[46]->in[48] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[46]->in[48] mux_2level_size50[46]->in[48] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[46]->in[49] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[46]->in[49] mux_2level_size50[46]->in[49] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
Vgvdd_mux_2level_size50[46] gvdd_mux_2level_size50[46] 0 vsp
***** Measurements *****
***** Rise delay *****
.meas tran delay_rise_idle_mux50[46]_in[4]_crossbar trig v(mux_2level_size50[46]->in[0]) val='input_thres_pct_rise*vsp' rise=1 td='clock_period'
+          targ v(mux_2level_size50[46]->out) val='output_thres_pct_rise*vsp' rise=1 td='clock_period'
***** Fall delay *****
.meas tran delay_fall_idle_mux50[46]_in[4]_crossbar trig v(mux_2level_size50[46]->in[0]) val='input_thres_pct_fall*vsp' fall=1 td='clock_period'
+          targ v(mux_2level_size50[46]->out) val='output_thres_pct_fall*vsp' fall=1 td='clock_period'
***** Rise timing period *****
.meas start_rise_idle_mux50[46]_in[4]_crossbar when v(mux_2level_size50[46]->in[0])='slew_lower_thres_pct_rise*vsp' rise=1 td='clock_period'
.meas tran switch_rise_idle_mux50[46]_in[4]_crossbar trig v(mux_2level_size50[46]->in[0]) val='slew_lower_thres_pct_rise*vsp' rise=1 td='clock_period'
+          targ v(mux_2level_size50[46]->out) val='slew_upper_thres_pct_rise*vsp' rise=1 td='clock_period'
***** Fall timing period *****
.meas start_fall_idle_mux50[46]_in[4]_crossbar when v(mux_2level_size50[46]->in[0])='slew_lower_thres_pct_fall*vsp' fall=1 td='clock_period'
.meas tran switch_fall_idle_mux50[46]_in[4]_crossbar trig v(mux_2level_size50[46]->in[0]) val='slew_lower_thres_pct_fall*vsp' fall=1 td='clock_period'
+          targ v(mux_2level_size50[46]->out) val='slew_upper_thres_pct_fall*vsp' fall=1 td='clock_period'
***** Leakage Power Measurement *****
.meas tran mux_2level_size50[46]_leakage_power avg p(Vgvdd_mux_2level_size50[46]) from=0 to='clock_period'
.meas tran leakage_idle_mux50[46]_in[4]_crossbar param='mux_2level_size50[46]_leakage_power'
***** Dynamic Power Measurement *****
.meas tran mux_2level_size50[46]_dynamic_power avg p(Vgvdd_mux_2level_size50[46]) from='clock_period' to='6*clock_period'
.meas tran mux_2level_size50[46]_energy_per_cycle param='mux_2level_size50[46]_dynamic_power*clock_period'
.meas tran dynamic_power_idle_mux50[46]_in[4]_crossbar  param='mux_2level_size50[46]_dynamic_power'
.meas tran energy_per_cycle_idle_mux50[46]_in[4]_crossbar  param='dynamic_power_idle_mux50[46]_in[4]_crossbar*clock_period'
.meas tran dynamic_rise_idle_mux50[46]_in[4]_crossbar avg p(Vgvdd_mux_2level_size50[46]) from='start_rise_idle_mux50[46]_in[4]_crossbar' to='start_rise_idle_mux50[46]_in[4]_crossbar+switch_rise_idle_mux50[46]_in[4]_crossbar'
.meas tran dynamic_fall_idle_mux50[46]_in[4]_crossbar avg p(Vgvdd_mux_2level_size50[46]) from='start_fall_idle_mux50[46]_in[4]_crossbar' to='start_fall_idle_mux50[46]_in[4]_crossbar+switch_fall_idle_mux50[46]_in[4]_crossbar'
.meas tran sum_leakage_power_mux[0to46]
+          param='sum_leakage_power_mux[0to45]+leakage_idle_mux50[46]_in[4]_crossbar'
.meas tran sum_energy_per_cycle_mux[0to46]
+          param='sum_energy_per_cycle_mux[0to45]+energy_per_cycle_idle_mux50[46]_in[4]_crossbar'
Xload_inv[46]_no0 mux_2level_size50[46]->out mux_2level_size50[46]->out_out[0] gvdd_load 0 inv size=5
.meas tran sum_leakage_power_pb_mux[0to46]
+          param='sum_leakage_power_pb_mux[0to45]+leakage_idle_mux50[46]_in[4]_crossbar'
.meas tran sum_energy_per_cycle_pb_mux[0to46]
+          param='sum_energy_per_cycle_pb_mux[0to45]+energy_per_cycle_idle_mux50[46]_in[4]_crossbar'
Xmux_2level_size50[47] mux_2level_size50[47]->in[0] mux_2level_size50[47]->in[1] mux_2level_size50[47]->in[2] mux_2level_size50[47]->in[3] mux_2level_size50[47]->in[4] mux_2level_size50[47]->in[5] mux_2level_size50[47]->in[6] mux_2level_size50[47]->in[7] mux_2level_size50[47]->in[8] mux_2level_size50[47]->in[9] mux_2level_size50[47]->in[10] mux_2level_size50[47]->in[11] mux_2level_size50[47]->in[12] mux_2level_size50[47]->in[13] mux_2level_size50[47]->in[14] mux_2level_size50[47]->in[15] mux_2level_size50[47]->in[16] mux_2level_size50[47]->in[17] mux_2level_size50[47]->in[18] mux_2level_size50[47]->in[19] mux_2level_size50[47]->in[20] mux_2level_size50[47]->in[21] mux_2level_size50[47]->in[22] mux_2level_size50[47]->in[23] mux_2level_size50[47]->in[24] mux_2level_size50[47]->in[25] mux_2level_size50[47]->in[26] mux_2level_size50[47]->in[27] mux_2level_size50[47]->in[28] mux_2level_size50[47]->in[29] mux_2level_size50[47]->in[30] mux_2level_size50[47]->in[31] mux_2level_size50[47]->in[32] mux_2level_size50[47]->in[33] mux_2level_size50[47]->in[34] mux_2level_size50[47]->in[35] mux_2level_size50[47]->in[36] mux_2level_size50[47]->in[37] mux_2level_size50[47]->in[38] mux_2level_size50[47]->in[39] mux_2level_size50[47]->in[40] mux_2level_size50[47]->in[41] mux_2level_size50[47]->in[42] mux_2level_size50[47]->in[43] mux_2level_size50[47]->in[44] mux_2level_size50[47]->in[45] mux_2level_size50[47]->in[46] mux_2level_size50[47]->in[47] mux_2level_size50[47]->in[48] mux_2level_size50[47]->in[49] mux_2level_size50[47]->out sram[752]->outb sram[752]->out sram[753]->out sram[753]->outb sram[754]->out sram[754]->outb sram[755]->out sram[755]->outb sram[756]->out sram[756]->outb sram[757]->out sram[757]->outb sram[758]->out sram[758]->outb sram[759]->out sram[759]->outb sram[760]->outb sram[760]->out sram[761]->out sram[761]->outb sram[762]->out sram[762]->outb sram[763]->out sram[763]->outb sram[764]->out sram[764]->outb sram[765]->out sram[765]->outb sram[766]->out sram[766]->outb sram[767]->out sram[767]->outb gvdd_mux_2level_size50[47] 0 mux_2level_size50
***** SRAM bits for MUX[47], level=2, select_path_id=0. *****
*****1000000010000000*****
Xsram[752] sram->in sram[752]->out sram[752]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[752]->out) 0
.nodeset V(sram[752]->outb) vsp
Xsram[753] sram->in sram[753]->out sram[753]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[753]->out) 0
.nodeset V(sram[753]->outb) vsp
Xsram[754] sram->in sram[754]->out sram[754]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[754]->out) 0
.nodeset V(sram[754]->outb) vsp
Xsram[755] sram->in sram[755]->out sram[755]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[755]->out) 0
.nodeset V(sram[755]->outb) vsp
Xsram[756] sram->in sram[756]->out sram[756]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[756]->out) 0
.nodeset V(sram[756]->outb) vsp
Xsram[757] sram->in sram[757]->out sram[757]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[757]->out) 0
.nodeset V(sram[757]->outb) vsp
Xsram[758] sram->in sram[758]->out sram[758]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[758]->out) 0
.nodeset V(sram[758]->outb) vsp
Xsram[759] sram->in sram[759]->out sram[759]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[759]->out) 0
.nodeset V(sram[759]->outb) vsp
Xsram[760] sram->in sram[760]->out sram[760]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[760]->out) 0
.nodeset V(sram[760]->outb) vsp
Xsram[761] sram->in sram[761]->out sram[761]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[761]->out) 0
.nodeset V(sram[761]->outb) vsp
Xsram[762] sram->in sram[762]->out sram[762]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[762]->out) 0
.nodeset V(sram[762]->outb) vsp
Xsram[763] sram->in sram[763]->out sram[763]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[763]->out) 0
.nodeset V(sram[763]->outb) vsp
Xsram[764] sram->in sram[764]->out sram[764]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[764]->out) 0
.nodeset V(sram[764]->outb) vsp
Xsram[765] sram->in sram[765]->out sram[765]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[765]->out) 0
.nodeset V(sram[765]->outb) vsp
Xsram[766] sram->in sram[766]->out sram[766]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[766]->out) 0
.nodeset V(sram[766]->outb) vsp
Xsram[767] sram->in sram[767]->out sram[767]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[767]->out) 0
.nodeset V(sram[767]->outb) vsp
***** Signal mux_2level_size50[47]->in[0] density = 0, probability=0.*****
Vmux_2level_size50[47]->in[0] mux_2level_size50[47]->in[0] 0
+  0
***** Signal mux_2level_size50[47]->in[1] density = 0, probability=0.*****
Vmux_2level_size50[47]->in[1] mux_2level_size50[47]->in[1] 0
+  0
***** Signal mux_2level_size50[47]->in[2] density = 0, probability=0.*****
Vmux_2level_size50[47]->in[2] mux_2level_size50[47]->in[2] 0
+  0
***** Signal mux_2level_size50[47]->in[3] density = 0, probability=0.*****
Vmux_2level_size50[47]->in[3] mux_2level_size50[47]->in[3] 0
+  0
***** Signal mux_2level_size50[47]->in[4] density = 0, probability=0.*****
Vmux_2level_size50[47]->in[4] mux_2level_size50[47]->in[4] 0
+  0
***** Signal mux_2level_size50[47]->in[5] density = 0, probability=0.*****
Vmux_2level_size50[47]->in[5] mux_2level_size50[47]->in[5] 0
+  0
***** Signal mux_2level_size50[47]->in[6] density = 0, probability=0.*****
Vmux_2level_size50[47]->in[6] mux_2level_size50[47]->in[6] 0
+  0
***** Signal mux_2level_size50[47]->in[7] density = 0, probability=0.*****
Vmux_2level_size50[47]->in[7] mux_2level_size50[47]->in[7] 0
+  0
***** Signal mux_2level_size50[47]->in[8] density = 0, probability=0.*****
Vmux_2level_size50[47]->in[8] mux_2level_size50[47]->in[8] 0
+  0
***** Signal mux_2level_size50[47]->in[9] density = 0, probability=0.*****
Vmux_2level_size50[47]->in[9] mux_2level_size50[47]->in[9] 0
+  0
***** Signal mux_2level_size50[47]->in[10] density = 0, probability=0.*****
Vmux_2level_size50[47]->in[10] mux_2level_size50[47]->in[10] 0
+  0
***** Signal mux_2level_size50[47]->in[11] density = 0, probability=0.*****
Vmux_2level_size50[47]->in[11] mux_2level_size50[47]->in[11] 0
+  0
***** Signal mux_2level_size50[47]->in[12] density = 0, probability=0.*****
Vmux_2level_size50[47]->in[12] mux_2level_size50[47]->in[12] 0
+  0
***** Signal mux_2level_size50[47]->in[13] density = 0, probability=0.*****
Vmux_2level_size50[47]->in[13] mux_2level_size50[47]->in[13] 0
+  0
***** Signal mux_2level_size50[47]->in[14] density = 0, probability=0.*****
Vmux_2level_size50[47]->in[14] mux_2level_size50[47]->in[14] 0
+  0
***** Signal mux_2level_size50[47]->in[15] density = 0, probability=0.*****
Vmux_2level_size50[47]->in[15] mux_2level_size50[47]->in[15] 0
+  0
***** Signal mux_2level_size50[47]->in[16] density = 0, probability=0.*****
Vmux_2level_size50[47]->in[16] mux_2level_size50[47]->in[16] 0
+  0
***** Signal mux_2level_size50[47]->in[17] density = 0, probability=0.*****
Vmux_2level_size50[47]->in[17] mux_2level_size50[47]->in[17] 0
+  0
***** Signal mux_2level_size50[47]->in[18] density = 0, probability=0.*****
Vmux_2level_size50[47]->in[18] mux_2level_size50[47]->in[18] 0
+  0
***** Signal mux_2level_size50[47]->in[19] density = 0, probability=0.*****
Vmux_2level_size50[47]->in[19] mux_2level_size50[47]->in[19] 0
+  0
***** Signal mux_2level_size50[47]->in[20] density = 0, probability=0.*****
Vmux_2level_size50[47]->in[20] mux_2level_size50[47]->in[20] 0
+  0
***** Signal mux_2level_size50[47]->in[21] density = 0, probability=0.*****
Vmux_2level_size50[47]->in[21] mux_2level_size50[47]->in[21] 0
+  0
***** Signal mux_2level_size50[47]->in[22] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[47]->in[22] mux_2level_size50[47]->in[22] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[47]->in[23] density = 0, probability=0.*****
Vmux_2level_size50[47]->in[23] mux_2level_size50[47]->in[23] 0
+  0
***** Signal mux_2level_size50[47]->in[24] density = 0, probability=0.*****
Vmux_2level_size50[47]->in[24] mux_2level_size50[47]->in[24] 0
+  0
***** Signal mux_2level_size50[47]->in[25] density = 0, probability=0.*****
Vmux_2level_size50[47]->in[25] mux_2level_size50[47]->in[25] 0
+  0
***** Signal mux_2level_size50[47]->in[26] density = 0, probability=0.*****
Vmux_2level_size50[47]->in[26] mux_2level_size50[47]->in[26] 0
+  0
***** Signal mux_2level_size50[47]->in[27] density = 0, probability=0.*****
Vmux_2level_size50[47]->in[27] mux_2level_size50[47]->in[27] 0
+  0
***** Signal mux_2level_size50[47]->in[28] density = 0, probability=0.*****
Vmux_2level_size50[47]->in[28] mux_2level_size50[47]->in[28] 0
+  0
***** Signal mux_2level_size50[47]->in[29] density = 0, probability=0.*****
Vmux_2level_size50[47]->in[29] mux_2level_size50[47]->in[29] 0
+  0
***** Signal mux_2level_size50[47]->in[30] density = 0, probability=0.*****
Vmux_2level_size50[47]->in[30] mux_2level_size50[47]->in[30] 0
+  0
***** Signal mux_2level_size50[47]->in[31] density = 0, probability=0.*****
Vmux_2level_size50[47]->in[31] mux_2level_size50[47]->in[31] 0
+  0
***** Signal mux_2level_size50[47]->in[32] density = 0, probability=0.*****
Vmux_2level_size50[47]->in[32] mux_2level_size50[47]->in[32] 0
+  0
***** Signal mux_2level_size50[47]->in[33] density = 0, probability=0.*****
Vmux_2level_size50[47]->in[33] mux_2level_size50[47]->in[33] 0
+  0
***** Signal mux_2level_size50[47]->in[34] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[47]->in[34] mux_2level_size50[47]->in[34] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[47]->in[35] density = 0, probability=0.*****
Vmux_2level_size50[47]->in[35] mux_2level_size50[47]->in[35] 0
+  0
***** Signal mux_2level_size50[47]->in[36] density = 0, probability=0.*****
Vmux_2level_size50[47]->in[36] mux_2level_size50[47]->in[36] 0
+  0
***** Signal mux_2level_size50[47]->in[37] density = 0, probability=0.*****
Vmux_2level_size50[47]->in[37] mux_2level_size50[47]->in[37] 0
+  0
***** Signal mux_2level_size50[47]->in[38] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[47]->in[38] mux_2level_size50[47]->in[38] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[47]->in[39] density = 0, probability=0.*****
Vmux_2level_size50[47]->in[39] mux_2level_size50[47]->in[39] 0
+  0
***** Signal mux_2level_size50[47]->in[40] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[47]->in[40] mux_2level_size50[47]->in[40] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[47]->in[41] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[47]->in[41] mux_2level_size50[47]->in[41] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[47]->in[42] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[47]->in[42] mux_2level_size50[47]->in[42] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[47]->in[43] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[47]->in[43] mux_2level_size50[47]->in[43] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[47]->in[44] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[47]->in[44] mux_2level_size50[47]->in[44] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[47]->in[45] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[47]->in[45] mux_2level_size50[47]->in[45] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[47]->in[46] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[47]->in[46] mux_2level_size50[47]->in[46] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[47]->in[47] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[47]->in[47] mux_2level_size50[47]->in[47] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[47]->in[48] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[47]->in[48] mux_2level_size50[47]->in[48] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[47]->in[49] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[47]->in[49] mux_2level_size50[47]->in[49] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
Vgvdd_mux_2level_size50[47] gvdd_mux_2level_size50[47] 0 vsp
***** Measurements *****
***** Rise delay *****
.meas tran delay_rise_idle_mux50[47]_in[5]_crossbar trig v(mux_2level_size50[47]->in[0]) val='input_thres_pct_rise*vsp' rise=1 td='clock_period'
+          targ v(mux_2level_size50[47]->out) val='output_thres_pct_rise*vsp' rise=1 td='clock_period'
***** Fall delay *****
.meas tran delay_fall_idle_mux50[47]_in[5]_crossbar trig v(mux_2level_size50[47]->in[0]) val='input_thres_pct_fall*vsp' fall=1 td='clock_period'
+          targ v(mux_2level_size50[47]->out) val='output_thres_pct_fall*vsp' fall=1 td='clock_period'
***** Rise timing period *****
.meas start_rise_idle_mux50[47]_in[5]_crossbar when v(mux_2level_size50[47]->in[0])='slew_lower_thres_pct_rise*vsp' rise=1 td='clock_period'
.meas tran switch_rise_idle_mux50[47]_in[5]_crossbar trig v(mux_2level_size50[47]->in[0]) val='slew_lower_thres_pct_rise*vsp' rise=1 td='clock_period'
+          targ v(mux_2level_size50[47]->out) val='slew_upper_thres_pct_rise*vsp' rise=1 td='clock_period'
***** Fall timing period *****
.meas start_fall_idle_mux50[47]_in[5]_crossbar when v(mux_2level_size50[47]->in[0])='slew_lower_thres_pct_fall*vsp' fall=1 td='clock_period'
.meas tran switch_fall_idle_mux50[47]_in[5]_crossbar trig v(mux_2level_size50[47]->in[0]) val='slew_lower_thres_pct_fall*vsp' fall=1 td='clock_period'
+          targ v(mux_2level_size50[47]->out) val='slew_upper_thres_pct_fall*vsp' fall=1 td='clock_period'
***** Leakage Power Measurement *****
.meas tran mux_2level_size50[47]_leakage_power avg p(Vgvdd_mux_2level_size50[47]) from=0 to='clock_period'
.meas tran leakage_idle_mux50[47]_in[5]_crossbar param='mux_2level_size50[47]_leakage_power'
***** Dynamic Power Measurement *****
.meas tran mux_2level_size50[47]_dynamic_power avg p(Vgvdd_mux_2level_size50[47]) from='clock_period' to='6*clock_period'
.meas tran mux_2level_size50[47]_energy_per_cycle param='mux_2level_size50[47]_dynamic_power*clock_period'
.meas tran dynamic_power_idle_mux50[47]_in[5]_crossbar  param='mux_2level_size50[47]_dynamic_power'
.meas tran energy_per_cycle_idle_mux50[47]_in[5]_crossbar  param='dynamic_power_idle_mux50[47]_in[5]_crossbar*clock_period'
.meas tran dynamic_rise_idle_mux50[47]_in[5]_crossbar avg p(Vgvdd_mux_2level_size50[47]) from='start_rise_idle_mux50[47]_in[5]_crossbar' to='start_rise_idle_mux50[47]_in[5]_crossbar+switch_rise_idle_mux50[47]_in[5]_crossbar'
.meas tran dynamic_fall_idle_mux50[47]_in[5]_crossbar avg p(Vgvdd_mux_2level_size50[47]) from='start_fall_idle_mux50[47]_in[5]_crossbar' to='start_fall_idle_mux50[47]_in[5]_crossbar+switch_fall_idle_mux50[47]_in[5]_crossbar'
.meas tran sum_leakage_power_mux[0to47]
+          param='sum_leakage_power_mux[0to46]+leakage_idle_mux50[47]_in[5]_crossbar'
.meas tran sum_energy_per_cycle_mux[0to47]
+          param='sum_energy_per_cycle_mux[0to46]+energy_per_cycle_idle_mux50[47]_in[5]_crossbar'
Xload_inv[47]_no0 mux_2level_size50[47]->out mux_2level_size50[47]->out_out[0] gvdd_load 0 inv size=5
.meas tran sum_leakage_power_pb_mux[0to47]
+          param='sum_leakage_power_pb_mux[0to46]+leakage_idle_mux50[47]_in[5]_crossbar'
.meas tran sum_energy_per_cycle_pb_mux[0to47]
+          param='sum_energy_per_cycle_pb_mux[0to46]+energy_per_cycle_idle_mux50[47]_in[5]_crossbar'
Xmux_2level_size50[48] mux_2level_size50[48]->in[0] mux_2level_size50[48]->in[1] mux_2level_size50[48]->in[2] mux_2level_size50[48]->in[3] mux_2level_size50[48]->in[4] mux_2level_size50[48]->in[5] mux_2level_size50[48]->in[6] mux_2level_size50[48]->in[7] mux_2level_size50[48]->in[8] mux_2level_size50[48]->in[9] mux_2level_size50[48]->in[10] mux_2level_size50[48]->in[11] mux_2level_size50[48]->in[12] mux_2level_size50[48]->in[13] mux_2level_size50[48]->in[14] mux_2level_size50[48]->in[15] mux_2level_size50[48]->in[16] mux_2level_size50[48]->in[17] mux_2level_size50[48]->in[18] mux_2level_size50[48]->in[19] mux_2level_size50[48]->in[20] mux_2level_size50[48]->in[21] mux_2level_size50[48]->in[22] mux_2level_size50[48]->in[23] mux_2level_size50[48]->in[24] mux_2level_size50[48]->in[25] mux_2level_size50[48]->in[26] mux_2level_size50[48]->in[27] mux_2level_size50[48]->in[28] mux_2level_size50[48]->in[29] mux_2level_size50[48]->in[30] mux_2level_size50[48]->in[31] mux_2level_size50[48]->in[32] mux_2level_size50[48]->in[33] mux_2level_size50[48]->in[34] mux_2level_size50[48]->in[35] mux_2level_size50[48]->in[36] mux_2level_size50[48]->in[37] mux_2level_size50[48]->in[38] mux_2level_size50[48]->in[39] mux_2level_size50[48]->in[40] mux_2level_size50[48]->in[41] mux_2level_size50[48]->in[42] mux_2level_size50[48]->in[43] mux_2level_size50[48]->in[44] mux_2level_size50[48]->in[45] mux_2level_size50[48]->in[46] mux_2level_size50[48]->in[47] mux_2level_size50[48]->in[48] mux_2level_size50[48]->in[49] mux_2level_size50[48]->out sram[768]->outb sram[768]->out sram[769]->out sram[769]->outb sram[770]->out sram[770]->outb sram[771]->out sram[771]->outb sram[772]->out sram[772]->outb sram[773]->out sram[773]->outb sram[774]->out sram[774]->outb sram[775]->out sram[775]->outb sram[776]->outb sram[776]->out sram[777]->out sram[777]->outb sram[778]->out sram[778]->outb sram[779]->out sram[779]->outb sram[780]->out sram[780]->outb sram[781]->out sram[781]->outb sram[782]->out sram[782]->outb sram[783]->out sram[783]->outb gvdd_mux_2level_size50[48] 0 mux_2level_size50
***** SRAM bits for MUX[48], level=2, select_path_id=0. *****
*****1000000010000000*****
Xsram[768] sram->in sram[768]->out sram[768]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[768]->out) 0
.nodeset V(sram[768]->outb) vsp
Xsram[769] sram->in sram[769]->out sram[769]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[769]->out) 0
.nodeset V(sram[769]->outb) vsp
Xsram[770] sram->in sram[770]->out sram[770]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[770]->out) 0
.nodeset V(sram[770]->outb) vsp
Xsram[771] sram->in sram[771]->out sram[771]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[771]->out) 0
.nodeset V(sram[771]->outb) vsp
Xsram[772] sram->in sram[772]->out sram[772]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[772]->out) 0
.nodeset V(sram[772]->outb) vsp
Xsram[773] sram->in sram[773]->out sram[773]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[773]->out) 0
.nodeset V(sram[773]->outb) vsp
Xsram[774] sram->in sram[774]->out sram[774]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[774]->out) 0
.nodeset V(sram[774]->outb) vsp
Xsram[775] sram->in sram[775]->out sram[775]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[775]->out) 0
.nodeset V(sram[775]->outb) vsp
Xsram[776] sram->in sram[776]->out sram[776]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[776]->out) 0
.nodeset V(sram[776]->outb) vsp
Xsram[777] sram->in sram[777]->out sram[777]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[777]->out) 0
.nodeset V(sram[777]->outb) vsp
Xsram[778] sram->in sram[778]->out sram[778]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[778]->out) 0
.nodeset V(sram[778]->outb) vsp
Xsram[779] sram->in sram[779]->out sram[779]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[779]->out) 0
.nodeset V(sram[779]->outb) vsp
Xsram[780] sram->in sram[780]->out sram[780]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[780]->out) 0
.nodeset V(sram[780]->outb) vsp
Xsram[781] sram->in sram[781]->out sram[781]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[781]->out) 0
.nodeset V(sram[781]->outb) vsp
Xsram[782] sram->in sram[782]->out sram[782]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[782]->out) 0
.nodeset V(sram[782]->outb) vsp
Xsram[783] sram->in sram[783]->out sram[783]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[783]->out) 0
.nodeset V(sram[783]->outb) vsp
***** Signal mux_2level_size50[48]->in[0] density = 0, probability=0.*****
Vmux_2level_size50[48]->in[0] mux_2level_size50[48]->in[0] 0
+  0
***** Signal mux_2level_size50[48]->in[1] density = 0, probability=0.*****
Vmux_2level_size50[48]->in[1] mux_2level_size50[48]->in[1] 0
+  0
***** Signal mux_2level_size50[48]->in[2] density = 0, probability=0.*****
Vmux_2level_size50[48]->in[2] mux_2level_size50[48]->in[2] 0
+  0
***** Signal mux_2level_size50[48]->in[3] density = 0, probability=0.*****
Vmux_2level_size50[48]->in[3] mux_2level_size50[48]->in[3] 0
+  0
***** Signal mux_2level_size50[48]->in[4] density = 0, probability=0.*****
Vmux_2level_size50[48]->in[4] mux_2level_size50[48]->in[4] 0
+  0
***** Signal mux_2level_size50[48]->in[5] density = 0, probability=0.*****
Vmux_2level_size50[48]->in[5] mux_2level_size50[48]->in[5] 0
+  0
***** Signal mux_2level_size50[48]->in[6] density = 0, probability=0.*****
Vmux_2level_size50[48]->in[6] mux_2level_size50[48]->in[6] 0
+  0
***** Signal mux_2level_size50[48]->in[7] density = 0, probability=0.*****
Vmux_2level_size50[48]->in[7] mux_2level_size50[48]->in[7] 0
+  0
***** Signal mux_2level_size50[48]->in[8] density = 0, probability=0.*****
Vmux_2level_size50[48]->in[8] mux_2level_size50[48]->in[8] 0
+  0
***** Signal mux_2level_size50[48]->in[9] density = 0, probability=0.*****
Vmux_2level_size50[48]->in[9] mux_2level_size50[48]->in[9] 0
+  0
***** Signal mux_2level_size50[48]->in[10] density = 0, probability=0.*****
Vmux_2level_size50[48]->in[10] mux_2level_size50[48]->in[10] 0
+  0
***** Signal mux_2level_size50[48]->in[11] density = 0, probability=0.*****
Vmux_2level_size50[48]->in[11] mux_2level_size50[48]->in[11] 0
+  0
***** Signal mux_2level_size50[48]->in[12] density = 0, probability=0.*****
Vmux_2level_size50[48]->in[12] mux_2level_size50[48]->in[12] 0
+  0
***** Signal mux_2level_size50[48]->in[13] density = 0, probability=0.*****
Vmux_2level_size50[48]->in[13] mux_2level_size50[48]->in[13] 0
+  0
***** Signal mux_2level_size50[48]->in[14] density = 0, probability=0.*****
Vmux_2level_size50[48]->in[14] mux_2level_size50[48]->in[14] 0
+  0
***** Signal mux_2level_size50[48]->in[15] density = 0, probability=0.*****
Vmux_2level_size50[48]->in[15] mux_2level_size50[48]->in[15] 0
+  0
***** Signal mux_2level_size50[48]->in[16] density = 0, probability=0.*****
Vmux_2level_size50[48]->in[16] mux_2level_size50[48]->in[16] 0
+  0
***** Signal mux_2level_size50[48]->in[17] density = 0, probability=0.*****
Vmux_2level_size50[48]->in[17] mux_2level_size50[48]->in[17] 0
+  0
***** Signal mux_2level_size50[48]->in[18] density = 0, probability=0.*****
Vmux_2level_size50[48]->in[18] mux_2level_size50[48]->in[18] 0
+  0
***** Signal mux_2level_size50[48]->in[19] density = 0, probability=0.*****
Vmux_2level_size50[48]->in[19] mux_2level_size50[48]->in[19] 0
+  0
***** Signal mux_2level_size50[48]->in[20] density = 0, probability=0.*****
Vmux_2level_size50[48]->in[20] mux_2level_size50[48]->in[20] 0
+  0
***** Signal mux_2level_size50[48]->in[21] density = 0, probability=0.*****
Vmux_2level_size50[48]->in[21] mux_2level_size50[48]->in[21] 0
+  0
***** Signal mux_2level_size50[48]->in[22] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[48]->in[22] mux_2level_size50[48]->in[22] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[48]->in[23] density = 0, probability=0.*****
Vmux_2level_size50[48]->in[23] mux_2level_size50[48]->in[23] 0
+  0
***** Signal mux_2level_size50[48]->in[24] density = 0, probability=0.*****
Vmux_2level_size50[48]->in[24] mux_2level_size50[48]->in[24] 0
+  0
***** Signal mux_2level_size50[48]->in[25] density = 0, probability=0.*****
Vmux_2level_size50[48]->in[25] mux_2level_size50[48]->in[25] 0
+  0
***** Signal mux_2level_size50[48]->in[26] density = 0, probability=0.*****
Vmux_2level_size50[48]->in[26] mux_2level_size50[48]->in[26] 0
+  0
***** Signal mux_2level_size50[48]->in[27] density = 0, probability=0.*****
Vmux_2level_size50[48]->in[27] mux_2level_size50[48]->in[27] 0
+  0
***** Signal mux_2level_size50[48]->in[28] density = 0, probability=0.*****
Vmux_2level_size50[48]->in[28] mux_2level_size50[48]->in[28] 0
+  0
***** Signal mux_2level_size50[48]->in[29] density = 0, probability=0.*****
Vmux_2level_size50[48]->in[29] mux_2level_size50[48]->in[29] 0
+  0
***** Signal mux_2level_size50[48]->in[30] density = 0, probability=0.*****
Vmux_2level_size50[48]->in[30] mux_2level_size50[48]->in[30] 0
+  0
***** Signal mux_2level_size50[48]->in[31] density = 0, probability=0.*****
Vmux_2level_size50[48]->in[31] mux_2level_size50[48]->in[31] 0
+  0
***** Signal mux_2level_size50[48]->in[32] density = 0, probability=0.*****
Vmux_2level_size50[48]->in[32] mux_2level_size50[48]->in[32] 0
+  0
***** Signal mux_2level_size50[48]->in[33] density = 0, probability=0.*****
Vmux_2level_size50[48]->in[33] mux_2level_size50[48]->in[33] 0
+  0
***** Signal mux_2level_size50[48]->in[34] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[48]->in[34] mux_2level_size50[48]->in[34] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[48]->in[35] density = 0, probability=0.*****
Vmux_2level_size50[48]->in[35] mux_2level_size50[48]->in[35] 0
+  0
***** Signal mux_2level_size50[48]->in[36] density = 0, probability=0.*****
Vmux_2level_size50[48]->in[36] mux_2level_size50[48]->in[36] 0
+  0
***** Signal mux_2level_size50[48]->in[37] density = 0, probability=0.*****
Vmux_2level_size50[48]->in[37] mux_2level_size50[48]->in[37] 0
+  0
***** Signal mux_2level_size50[48]->in[38] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[48]->in[38] mux_2level_size50[48]->in[38] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[48]->in[39] density = 0, probability=0.*****
Vmux_2level_size50[48]->in[39] mux_2level_size50[48]->in[39] 0
+  0
***** Signal mux_2level_size50[48]->in[40] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[48]->in[40] mux_2level_size50[48]->in[40] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[48]->in[41] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[48]->in[41] mux_2level_size50[48]->in[41] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[48]->in[42] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[48]->in[42] mux_2level_size50[48]->in[42] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[48]->in[43] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[48]->in[43] mux_2level_size50[48]->in[43] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[48]->in[44] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[48]->in[44] mux_2level_size50[48]->in[44] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[48]->in[45] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[48]->in[45] mux_2level_size50[48]->in[45] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[48]->in[46] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[48]->in[46] mux_2level_size50[48]->in[46] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[48]->in[47] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[48]->in[47] mux_2level_size50[48]->in[47] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[48]->in[48] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[48]->in[48] mux_2level_size50[48]->in[48] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[48]->in[49] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[48]->in[49] mux_2level_size50[48]->in[49] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
Vgvdd_mux_2level_size50[48] gvdd_mux_2level_size50[48] 0 vsp
***** Measurements *****
***** Rise delay *****
.meas tran delay_rise_idle_mux50[48]_in[0]_crossbar trig v(mux_2level_size50[48]->in[0]) val='input_thres_pct_rise*vsp' rise=1 td='clock_period'
+          targ v(mux_2level_size50[48]->out) val='output_thres_pct_rise*vsp' rise=1 td='clock_period'
***** Fall delay *****
.meas tran delay_fall_idle_mux50[48]_in[0]_crossbar trig v(mux_2level_size50[48]->in[0]) val='input_thres_pct_fall*vsp' fall=1 td='clock_period'
+          targ v(mux_2level_size50[48]->out) val='output_thres_pct_fall*vsp' fall=1 td='clock_period'
***** Rise timing period *****
.meas start_rise_idle_mux50[48]_in[0]_crossbar when v(mux_2level_size50[48]->in[0])='slew_lower_thres_pct_rise*vsp' rise=1 td='clock_period'
.meas tran switch_rise_idle_mux50[48]_in[0]_crossbar trig v(mux_2level_size50[48]->in[0]) val='slew_lower_thres_pct_rise*vsp' rise=1 td='clock_period'
+          targ v(mux_2level_size50[48]->out) val='slew_upper_thres_pct_rise*vsp' rise=1 td='clock_period'
***** Fall timing period *****
.meas start_fall_idle_mux50[48]_in[0]_crossbar when v(mux_2level_size50[48]->in[0])='slew_lower_thres_pct_fall*vsp' fall=1 td='clock_period'
.meas tran switch_fall_idle_mux50[48]_in[0]_crossbar trig v(mux_2level_size50[48]->in[0]) val='slew_lower_thres_pct_fall*vsp' fall=1 td='clock_period'
+          targ v(mux_2level_size50[48]->out) val='slew_upper_thres_pct_fall*vsp' fall=1 td='clock_period'
***** Leakage Power Measurement *****
.meas tran mux_2level_size50[48]_leakage_power avg p(Vgvdd_mux_2level_size50[48]) from=0 to='clock_period'
.meas tran leakage_idle_mux50[48]_in[0]_crossbar param='mux_2level_size50[48]_leakage_power'
***** Dynamic Power Measurement *****
.meas tran mux_2level_size50[48]_dynamic_power avg p(Vgvdd_mux_2level_size50[48]) from='clock_period' to='6*clock_period'
.meas tran mux_2level_size50[48]_energy_per_cycle param='mux_2level_size50[48]_dynamic_power*clock_period'
.meas tran dynamic_power_idle_mux50[48]_in[0]_crossbar  param='mux_2level_size50[48]_dynamic_power'
.meas tran energy_per_cycle_idle_mux50[48]_in[0]_crossbar  param='dynamic_power_idle_mux50[48]_in[0]_crossbar*clock_period'
.meas tran dynamic_rise_idle_mux50[48]_in[0]_crossbar avg p(Vgvdd_mux_2level_size50[48]) from='start_rise_idle_mux50[48]_in[0]_crossbar' to='start_rise_idle_mux50[48]_in[0]_crossbar+switch_rise_idle_mux50[48]_in[0]_crossbar'
.meas tran dynamic_fall_idle_mux50[48]_in[0]_crossbar avg p(Vgvdd_mux_2level_size50[48]) from='start_fall_idle_mux50[48]_in[0]_crossbar' to='start_fall_idle_mux50[48]_in[0]_crossbar+switch_fall_idle_mux50[48]_in[0]_crossbar'
.meas tran sum_leakage_power_mux[0to48]
+          param='sum_leakage_power_mux[0to47]+leakage_idle_mux50[48]_in[0]_crossbar'
.meas tran sum_energy_per_cycle_mux[0to48]
+          param='sum_energy_per_cycle_mux[0to47]+energy_per_cycle_idle_mux50[48]_in[0]_crossbar'
Xload_inv[48]_no0 mux_2level_size50[48]->out mux_2level_size50[48]->out_out[0] gvdd_load 0 inv size=5
.meas tran sum_leakage_power_pb_mux[0to48]
+          param='sum_leakage_power_pb_mux[0to47]+leakage_idle_mux50[48]_in[0]_crossbar'
.meas tran sum_energy_per_cycle_pb_mux[0to48]
+          param='sum_energy_per_cycle_pb_mux[0to47]+energy_per_cycle_idle_mux50[48]_in[0]_crossbar'
Xmux_2level_size50[49] mux_2level_size50[49]->in[0] mux_2level_size50[49]->in[1] mux_2level_size50[49]->in[2] mux_2level_size50[49]->in[3] mux_2level_size50[49]->in[4] mux_2level_size50[49]->in[5] mux_2level_size50[49]->in[6] mux_2level_size50[49]->in[7] mux_2level_size50[49]->in[8] mux_2level_size50[49]->in[9] mux_2level_size50[49]->in[10] mux_2level_size50[49]->in[11] mux_2level_size50[49]->in[12] mux_2level_size50[49]->in[13] mux_2level_size50[49]->in[14] mux_2level_size50[49]->in[15] mux_2level_size50[49]->in[16] mux_2level_size50[49]->in[17] mux_2level_size50[49]->in[18] mux_2level_size50[49]->in[19] mux_2level_size50[49]->in[20] mux_2level_size50[49]->in[21] mux_2level_size50[49]->in[22] mux_2level_size50[49]->in[23] mux_2level_size50[49]->in[24] mux_2level_size50[49]->in[25] mux_2level_size50[49]->in[26] mux_2level_size50[49]->in[27] mux_2level_size50[49]->in[28] mux_2level_size50[49]->in[29] mux_2level_size50[49]->in[30] mux_2level_size50[49]->in[31] mux_2level_size50[49]->in[32] mux_2level_size50[49]->in[33] mux_2level_size50[49]->in[34] mux_2level_size50[49]->in[35] mux_2level_size50[49]->in[36] mux_2level_size50[49]->in[37] mux_2level_size50[49]->in[38] mux_2level_size50[49]->in[39] mux_2level_size50[49]->in[40] mux_2level_size50[49]->in[41] mux_2level_size50[49]->in[42] mux_2level_size50[49]->in[43] mux_2level_size50[49]->in[44] mux_2level_size50[49]->in[45] mux_2level_size50[49]->in[46] mux_2level_size50[49]->in[47] mux_2level_size50[49]->in[48] mux_2level_size50[49]->in[49] mux_2level_size50[49]->out sram[784]->outb sram[784]->out sram[785]->out sram[785]->outb sram[786]->out sram[786]->outb sram[787]->out sram[787]->outb sram[788]->out sram[788]->outb sram[789]->out sram[789]->outb sram[790]->out sram[790]->outb sram[791]->out sram[791]->outb sram[792]->outb sram[792]->out sram[793]->out sram[793]->outb sram[794]->out sram[794]->outb sram[795]->out sram[795]->outb sram[796]->out sram[796]->outb sram[797]->out sram[797]->outb sram[798]->out sram[798]->outb sram[799]->out sram[799]->outb gvdd_mux_2level_size50[49] 0 mux_2level_size50
***** SRAM bits for MUX[49], level=2, select_path_id=0. *****
*****1000000010000000*****
Xsram[784] sram->in sram[784]->out sram[784]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[784]->out) 0
.nodeset V(sram[784]->outb) vsp
Xsram[785] sram->in sram[785]->out sram[785]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[785]->out) 0
.nodeset V(sram[785]->outb) vsp
Xsram[786] sram->in sram[786]->out sram[786]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[786]->out) 0
.nodeset V(sram[786]->outb) vsp
Xsram[787] sram->in sram[787]->out sram[787]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[787]->out) 0
.nodeset V(sram[787]->outb) vsp
Xsram[788] sram->in sram[788]->out sram[788]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[788]->out) 0
.nodeset V(sram[788]->outb) vsp
Xsram[789] sram->in sram[789]->out sram[789]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[789]->out) 0
.nodeset V(sram[789]->outb) vsp
Xsram[790] sram->in sram[790]->out sram[790]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[790]->out) 0
.nodeset V(sram[790]->outb) vsp
Xsram[791] sram->in sram[791]->out sram[791]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[791]->out) 0
.nodeset V(sram[791]->outb) vsp
Xsram[792] sram->in sram[792]->out sram[792]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[792]->out) 0
.nodeset V(sram[792]->outb) vsp
Xsram[793] sram->in sram[793]->out sram[793]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[793]->out) 0
.nodeset V(sram[793]->outb) vsp
Xsram[794] sram->in sram[794]->out sram[794]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[794]->out) 0
.nodeset V(sram[794]->outb) vsp
Xsram[795] sram->in sram[795]->out sram[795]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[795]->out) 0
.nodeset V(sram[795]->outb) vsp
Xsram[796] sram->in sram[796]->out sram[796]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[796]->out) 0
.nodeset V(sram[796]->outb) vsp
Xsram[797] sram->in sram[797]->out sram[797]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[797]->out) 0
.nodeset V(sram[797]->outb) vsp
Xsram[798] sram->in sram[798]->out sram[798]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[798]->out) 0
.nodeset V(sram[798]->outb) vsp
Xsram[799] sram->in sram[799]->out sram[799]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[799]->out) 0
.nodeset V(sram[799]->outb) vsp
***** Signal mux_2level_size50[49]->in[0] density = 0, probability=0.*****
Vmux_2level_size50[49]->in[0] mux_2level_size50[49]->in[0] 0
+  0
***** Signal mux_2level_size50[49]->in[1] density = 0, probability=0.*****
Vmux_2level_size50[49]->in[1] mux_2level_size50[49]->in[1] 0
+  0
***** Signal mux_2level_size50[49]->in[2] density = 0, probability=0.*****
Vmux_2level_size50[49]->in[2] mux_2level_size50[49]->in[2] 0
+  0
***** Signal mux_2level_size50[49]->in[3] density = 0, probability=0.*****
Vmux_2level_size50[49]->in[3] mux_2level_size50[49]->in[3] 0
+  0
***** Signal mux_2level_size50[49]->in[4] density = 0, probability=0.*****
Vmux_2level_size50[49]->in[4] mux_2level_size50[49]->in[4] 0
+  0
***** Signal mux_2level_size50[49]->in[5] density = 0, probability=0.*****
Vmux_2level_size50[49]->in[5] mux_2level_size50[49]->in[5] 0
+  0
***** Signal mux_2level_size50[49]->in[6] density = 0, probability=0.*****
Vmux_2level_size50[49]->in[6] mux_2level_size50[49]->in[6] 0
+  0
***** Signal mux_2level_size50[49]->in[7] density = 0, probability=0.*****
Vmux_2level_size50[49]->in[7] mux_2level_size50[49]->in[7] 0
+  0
***** Signal mux_2level_size50[49]->in[8] density = 0, probability=0.*****
Vmux_2level_size50[49]->in[8] mux_2level_size50[49]->in[8] 0
+  0
***** Signal mux_2level_size50[49]->in[9] density = 0, probability=0.*****
Vmux_2level_size50[49]->in[9] mux_2level_size50[49]->in[9] 0
+  0
***** Signal mux_2level_size50[49]->in[10] density = 0, probability=0.*****
Vmux_2level_size50[49]->in[10] mux_2level_size50[49]->in[10] 0
+  0
***** Signal mux_2level_size50[49]->in[11] density = 0, probability=0.*****
Vmux_2level_size50[49]->in[11] mux_2level_size50[49]->in[11] 0
+  0
***** Signal mux_2level_size50[49]->in[12] density = 0, probability=0.*****
Vmux_2level_size50[49]->in[12] mux_2level_size50[49]->in[12] 0
+  0
***** Signal mux_2level_size50[49]->in[13] density = 0, probability=0.*****
Vmux_2level_size50[49]->in[13] mux_2level_size50[49]->in[13] 0
+  0
***** Signal mux_2level_size50[49]->in[14] density = 0, probability=0.*****
Vmux_2level_size50[49]->in[14] mux_2level_size50[49]->in[14] 0
+  0
***** Signal mux_2level_size50[49]->in[15] density = 0, probability=0.*****
Vmux_2level_size50[49]->in[15] mux_2level_size50[49]->in[15] 0
+  0
***** Signal mux_2level_size50[49]->in[16] density = 0, probability=0.*****
Vmux_2level_size50[49]->in[16] mux_2level_size50[49]->in[16] 0
+  0
***** Signal mux_2level_size50[49]->in[17] density = 0, probability=0.*****
Vmux_2level_size50[49]->in[17] mux_2level_size50[49]->in[17] 0
+  0
***** Signal mux_2level_size50[49]->in[18] density = 0, probability=0.*****
Vmux_2level_size50[49]->in[18] mux_2level_size50[49]->in[18] 0
+  0
***** Signal mux_2level_size50[49]->in[19] density = 0, probability=0.*****
Vmux_2level_size50[49]->in[19] mux_2level_size50[49]->in[19] 0
+  0
***** Signal mux_2level_size50[49]->in[20] density = 0, probability=0.*****
Vmux_2level_size50[49]->in[20] mux_2level_size50[49]->in[20] 0
+  0
***** Signal mux_2level_size50[49]->in[21] density = 0, probability=0.*****
Vmux_2level_size50[49]->in[21] mux_2level_size50[49]->in[21] 0
+  0
***** Signal mux_2level_size50[49]->in[22] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[49]->in[22] mux_2level_size50[49]->in[22] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[49]->in[23] density = 0, probability=0.*****
Vmux_2level_size50[49]->in[23] mux_2level_size50[49]->in[23] 0
+  0
***** Signal mux_2level_size50[49]->in[24] density = 0, probability=0.*****
Vmux_2level_size50[49]->in[24] mux_2level_size50[49]->in[24] 0
+  0
***** Signal mux_2level_size50[49]->in[25] density = 0, probability=0.*****
Vmux_2level_size50[49]->in[25] mux_2level_size50[49]->in[25] 0
+  0
***** Signal mux_2level_size50[49]->in[26] density = 0, probability=0.*****
Vmux_2level_size50[49]->in[26] mux_2level_size50[49]->in[26] 0
+  0
***** Signal mux_2level_size50[49]->in[27] density = 0, probability=0.*****
Vmux_2level_size50[49]->in[27] mux_2level_size50[49]->in[27] 0
+  0
***** Signal mux_2level_size50[49]->in[28] density = 0, probability=0.*****
Vmux_2level_size50[49]->in[28] mux_2level_size50[49]->in[28] 0
+  0
***** Signal mux_2level_size50[49]->in[29] density = 0, probability=0.*****
Vmux_2level_size50[49]->in[29] mux_2level_size50[49]->in[29] 0
+  0
***** Signal mux_2level_size50[49]->in[30] density = 0, probability=0.*****
Vmux_2level_size50[49]->in[30] mux_2level_size50[49]->in[30] 0
+  0
***** Signal mux_2level_size50[49]->in[31] density = 0, probability=0.*****
Vmux_2level_size50[49]->in[31] mux_2level_size50[49]->in[31] 0
+  0
***** Signal mux_2level_size50[49]->in[32] density = 0, probability=0.*****
Vmux_2level_size50[49]->in[32] mux_2level_size50[49]->in[32] 0
+  0
***** Signal mux_2level_size50[49]->in[33] density = 0, probability=0.*****
Vmux_2level_size50[49]->in[33] mux_2level_size50[49]->in[33] 0
+  0
***** Signal mux_2level_size50[49]->in[34] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[49]->in[34] mux_2level_size50[49]->in[34] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[49]->in[35] density = 0, probability=0.*****
Vmux_2level_size50[49]->in[35] mux_2level_size50[49]->in[35] 0
+  0
***** Signal mux_2level_size50[49]->in[36] density = 0, probability=0.*****
Vmux_2level_size50[49]->in[36] mux_2level_size50[49]->in[36] 0
+  0
***** Signal mux_2level_size50[49]->in[37] density = 0, probability=0.*****
Vmux_2level_size50[49]->in[37] mux_2level_size50[49]->in[37] 0
+  0
***** Signal mux_2level_size50[49]->in[38] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[49]->in[38] mux_2level_size50[49]->in[38] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[49]->in[39] density = 0, probability=0.*****
Vmux_2level_size50[49]->in[39] mux_2level_size50[49]->in[39] 0
+  0
***** Signal mux_2level_size50[49]->in[40] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[49]->in[40] mux_2level_size50[49]->in[40] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[49]->in[41] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[49]->in[41] mux_2level_size50[49]->in[41] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[49]->in[42] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[49]->in[42] mux_2level_size50[49]->in[42] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[49]->in[43] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[49]->in[43] mux_2level_size50[49]->in[43] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[49]->in[44] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[49]->in[44] mux_2level_size50[49]->in[44] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[49]->in[45] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[49]->in[45] mux_2level_size50[49]->in[45] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[49]->in[46] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[49]->in[46] mux_2level_size50[49]->in[46] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[49]->in[47] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[49]->in[47] mux_2level_size50[49]->in[47] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[49]->in[48] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[49]->in[48] mux_2level_size50[49]->in[48] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[49]->in[49] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[49]->in[49] mux_2level_size50[49]->in[49] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
Vgvdd_mux_2level_size50[49] gvdd_mux_2level_size50[49] 0 vsp
***** Measurements *****
***** Rise delay *****
.meas tran delay_rise_idle_mux50[49]_in[1]_crossbar trig v(mux_2level_size50[49]->in[0]) val='input_thres_pct_rise*vsp' rise=1 td='clock_period'
+          targ v(mux_2level_size50[49]->out) val='output_thres_pct_rise*vsp' rise=1 td='clock_period'
***** Fall delay *****
.meas tran delay_fall_idle_mux50[49]_in[1]_crossbar trig v(mux_2level_size50[49]->in[0]) val='input_thres_pct_fall*vsp' fall=1 td='clock_period'
+          targ v(mux_2level_size50[49]->out) val='output_thres_pct_fall*vsp' fall=1 td='clock_period'
***** Rise timing period *****
.meas start_rise_idle_mux50[49]_in[1]_crossbar when v(mux_2level_size50[49]->in[0])='slew_lower_thres_pct_rise*vsp' rise=1 td='clock_period'
.meas tran switch_rise_idle_mux50[49]_in[1]_crossbar trig v(mux_2level_size50[49]->in[0]) val='slew_lower_thres_pct_rise*vsp' rise=1 td='clock_period'
+          targ v(mux_2level_size50[49]->out) val='slew_upper_thres_pct_rise*vsp' rise=1 td='clock_period'
***** Fall timing period *****
.meas start_fall_idle_mux50[49]_in[1]_crossbar when v(mux_2level_size50[49]->in[0])='slew_lower_thres_pct_fall*vsp' fall=1 td='clock_period'
.meas tran switch_fall_idle_mux50[49]_in[1]_crossbar trig v(mux_2level_size50[49]->in[0]) val='slew_lower_thres_pct_fall*vsp' fall=1 td='clock_period'
+          targ v(mux_2level_size50[49]->out) val='slew_upper_thres_pct_fall*vsp' fall=1 td='clock_period'
***** Leakage Power Measurement *****
.meas tran mux_2level_size50[49]_leakage_power avg p(Vgvdd_mux_2level_size50[49]) from=0 to='clock_period'
.meas tran leakage_idle_mux50[49]_in[1]_crossbar param='mux_2level_size50[49]_leakage_power'
***** Dynamic Power Measurement *****
.meas tran mux_2level_size50[49]_dynamic_power avg p(Vgvdd_mux_2level_size50[49]) from='clock_period' to='6*clock_period'
.meas tran mux_2level_size50[49]_energy_per_cycle param='mux_2level_size50[49]_dynamic_power*clock_period'
.meas tran dynamic_power_idle_mux50[49]_in[1]_crossbar  param='mux_2level_size50[49]_dynamic_power'
.meas tran energy_per_cycle_idle_mux50[49]_in[1]_crossbar  param='dynamic_power_idle_mux50[49]_in[1]_crossbar*clock_period'
.meas tran dynamic_rise_idle_mux50[49]_in[1]_crossbar avg p(Vgvdd_mux_2level_size50[49]) from='start_rise_idle_mux50[49]_in[1]_crossbar' to='start_rise_idle_mux50[49]_in[1]_crossbar+switch_rise_idle_mux50[49]_in[1]_crossbar'
.meas tran dynamic_fall_idle_mux50[49]_in[1]_crossbar avg p(Vgvdd_mux_2level_size50[49]) from='start_fall_idle_mux50[49]_in[1]_crossbar' to='start_fall_idle_mux50[49]_in[1]_crossbar+switch_fall_idle_mux50[49]_in[1]_crossbar'
.meas tran sum_leakage_power_mux[0to49]
+          param='sum_leakage_power_mux[0to48]+leakage_idle_mux50[49]_in[1]_crossbar'
.meas tran sum_energy_per_cycle_mux[0to49]
+          param='sum_energy_per_cycle_mux[0to48]+energy_per_cycle_idle_mux50[49]_in[1]_crossbar'
Xload_inv[49]_no0 mux_2level_size50[49]->out mux_2level_size50[49]->out_out[0] gvdd_load 0 inv size=5
.meas tran sum_leakage_power_pb_mux[0to49]
+          param='sum_leakage_power_pb_mux[0to48]+leakage_idle_mux50[49]_in[1]_crossbar'
.meas tran sum_energy_per_cycle_pb_mux[0to49]
+          param='sum_energy_per_cycle_pb_mux[0to48]+energy_per_cycle_idle_mux50[49]_in[1]_crossbar'
Xmux_2level_size50[50] mux_2level_size50[50]->in[0] mux_2level_size50[50]->in[1] mux_2level_size50[50]->in[2] mux_2level_size50[50]->in[3] mux_2level_size50[50]->in[4] mux_2level_size50[50]->in[5] mux_2level_size50[50]->in[6] mux_2level_size50[50]->in[7] mux_2level_size50[50]->in[8] mux_2level_size50[50]->in[9] mux_2level_size50[50]->in[10] mux_2level_size50[50]->in[11] mux_2level_size50[50]->in[12] mux_2level_size50[50]->in[13] mux_2level_size50[50]->in[14] mux_2level_size50[50]->in[15] mux_2level_size50[50]->in[16] mux_2level_size50[50]->in[17] mux_2level_size50[50]->in[18] mux_2level_size50[50]->in[19] mux_2level_size50[50]->in[20] mux_2level_size50[50]->in[21] mux_2level_size50[50]->in[22] mux_2level_size50[50]->in[23] mux_2level_size50[50]->in[24] mux_2level_size50[50]->in[25] mux_2level_size50[50]->in[26] mux_2level_size50[50]->in[27] mux_2level_size50[50]->in[28] mux_2level_size50[50]->in[29] mux_2level_size50[50]->in[30] mux_2level_size50[50]->in[31] mux_2level_size50[50]->in[32] mux_2level_size50[50]->in[33] mux_2level_size50[50]->in[34] mux_2level_size50[50]->in[35] mux_2level_size50[50]->in[36] mux_2level_size50[50]->in[37] mux_2level_size50[50]->in[38] mux_2level_size50[50]->in[39] mux_2level_size50[50]->in[40] mux_2level_size50[50]->in[41] mux_2level_size50[50]->in[42] mux_2level_size50[50]->in[43] mux_2level_size50[50]->in[44] mux_2level_size50[50]->in[45] mux_2level_size50[50]->in[46] mux_2level_size50[50]->in[47] mux_2level_size50[50]->in[48] mux_2level_size50[50]->in[49] mux_2level_size50[50]->out sram[800]->outb sram[800]->out sram[801]->out sram[801]->outb sram[802]->out sram[802]->outb sram[803]->out sram[803]->outb sram[804]->out sram[804]->outb sram[805]->out sram[805]->outb sram[806]->out sram[806]->outb sram[807]->out sram[807]->outb sram[808]->outb sram[808]->out sram[809]->out sram[809]->outb sram[810]->out sram[810]->outb sram[811]->out sram[811]->outb sram[812]->out sram[812]->outb sram[813]->out sram[813]->outb sram[814]->out sram[814]->outb sram[815]->out sram[815]->outb gvdd_mux_2level_size50[50] 0 mux_2level_size50
***** SRAM bits for MUX[50], level=2, select_path_id=0. *****
*****1000000010000000*****
Xsram[800] sram->in sram[800]->out sram[800]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[800]->out) 0
.nodeset V(sram[800]->outb) vsp
Xsram[801] sram->in sram[801]->out sram[801]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[801]->out) 0
.nodeset V(sram[801]->outb) vsp
Xsram[802] sram->in sram[802]->out sram[802]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[802]->out) 0
.nodeset V(sram[802]->outb) vsp
Xsram[803] sram->in sram[803]->out sram[803]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[803]->out) 0
.nodeset V(sram[803]->outb) vsp
Xsram[804] sram->in sram[804]->out sram[804]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[804]->out) 0
.nodeset V(sram[804]->outb) vsp
Xsram[805] sram->in sram[805]->out sram[805]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[805]->out) 0
.nodeset V(sram[805]->outb) vsp
Xsram[806] sram->in sram[806]->out sram[806]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[806]->out) 0
.nodeset V(sram[806]->outb) vsp
Xsram[807] sram->in sram[807]->out sram[807]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[807]->out) 0
.nodeset V(sram[807]->outb) vsp
Xsram[808] sram->in sram[808]->out sram[808]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[808]->out) 0
.nodeset V(sram[808]->outb) vsp
Xsram[809] sram->in sram[809]->out sram[809]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[809]->out) 0
.nodeset V(sram[809]->outb) vsp
Xsram[810] sram->in sram[810]->out sram[810]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[810]->out) 0
.nodeset V(sram[810]->outb) vsp
Xsram[811] sram->in sram[811]->out sram[811]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[811]->out) 0
.nodeset V(sram[811]->outb) vsp
Xsram[812] sram->in sram[812]->out sram[812]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[812]->out) 0
.nodeset V(sram[812]->outb) vsp
Xsram[813] sram->in sram[813]->out sram[813]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[813]->out) 0
.nodeset V(sram[813]->outb) vsp
Xsram[814] sram->in sram[814]->out sram[814]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[814]->out) 0
.nodeset V(sram[814]->outb) vsp
Xsram[815] sram->in sram[815]->out sram[815]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[815]->out) 0
.nodeset V(sram[815]->outb) vsp
***** Signal mux_2level_size50[50]->in[0] density = 0, probability=0.*****
Vmux_2level_size50[50]->in[0] mux_2level_size50[50]->in[0] 0
+  0
***** Signal mux_2level_size50[50]->in[1] density = 0, probability=0.*****
Vmux_2level_size50[50]->in[1] mux_2level_size50[50]->in[1] 0
+  0
***** Signal mux_2level_size50[50]->in[2] density = 0, probability=0.*****
Vmux_2level_size50[50]->in[2] mux_2level_size50[50]->in[2] 0
+  0
***** Signal mux_2level_size50[50]->in[3] density = 0, probability=0.*****
Vmux_2level_size50[50]->in[3] mux_2level_size50[50]->in[3] 0
+  0
***** Signal mux_2level_size50[50]->in[4] density = 0, probability=0.*****
Vmux_2level_size50[50]->in[4] mux_2level_size50[50]->in[4] 0
+  0
***** Signal mux_2level_size50[50]->in[5] density = 0, probability=0.*****
Vmux_2level_size50[50]->in[5] mux_2level_size50[50]->in[5] 0
+  0
***** Signal mux_2level_size50[50]->in[6] density = 0, probability=0.*****
Vmux_2level_size50[50]->in[6] mux_2level_size50[50]->in[6] 0
+  0
***** Signal mux_2level_size50[50]->in[7] density = 0, probability=0.*****
Vmux_2level_size50[50]->in[7] mux_2level_size50[50]->in[7] 0
+  0
***** Signal mux_2level_size50[50]->in[8] density = 0, probability=0.*****
Vmux_2level_size50[50]->in[8] mux_2level_size50[50]->in[8] 0
+  0
***** Signal mux_2level_size50[50]->in[9] density = 0, probability=0.*****
Vmux_2level_size50[50]->in[9] mux_2level_size50[50]->in[9] 0
+  0
***** Signal mux_2level_size50[50]->in[10] density = 0, probability=0.*****
Vmux_2level_size50[50]->in[10] mux_2level_size50[50]->in[10] 0
+  0
***** Signal mux_2level_size50[50]->in[11] density = 0, probability=0.*****
Vmux_2level_size50[50]->in[11] mux_2level_size50[50]->in[11] 0
+  0
***** Signal mux_2level_size50[50]->in[12] density = 0, probability=0.*****
Vmux_2level_size50[50]->in[12] mux_2level_size50[50]->in[12] 0
+  0
***** Signal mux_2level_size50[50]->in[13] density = 0, probability=0.*****
Vmux_2level_size50[50]->in[13] mux_2level_size50[50]->in[13] 0
+  0
***** Signal mux_2level_size50[50]->in[14] density = 0, probability=0.*****
Vmux_2level_size50[50]->in[14] mux_2level_size50[50]->in[14] 0
+  0
***** Signal mux_2level_size50[50]->in[15] density = 0, probability=0.*****
Vmux_2level_size50[50]->in[15] mux_2level_size50[50]->in[15] 0
+  0
***** Signal mux_2level_size50[50]->in[16] density = 0, probability=0.*****
Vmux_2level_size50[50]->in[16] mux_2level_size50[50]->in[16] 0
+  0
***** Signal mux_2level_size50[50]->in[17] density = 0, probability=0.*****
Vmux_2level_size50[50]->in[17] mux_2level_size50[50]->in[17] 0
+  0
***** Signal mux_2level_size50[50]->in[18] density = 0, probability=0.*****
Vmux_2level_size50[50]->in[18] mux_2level_size50[50]->in[18] 0
+  0
***** Signal mux_2level_size50[50]->in[19] density = 0, probability=0.*****
Vmux_2level_size50[50]->in[19] mux_2level_size50[50]->in[19] 0
+  0
***** Signal mux_2level_size50[50]->in[20] density = 0, probability=0.*****
Vmux_2level_size50[50]->in[20] mux_2level_size50[50]->in[20] 0
+  0
***** Signal mux_2level_size50[50]->in[21] density = 0, probability=0.*****
Vmux_2level_size50[50]->in[21] mux_2level_size50[50]->in[21] 0
+  0
***** Signal mux_2level_size50[50]->in[22] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[50]->in[22] mux_2level_size50[50]->in[22] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[50]->in[23] density = 0, probability=0.*****
Vmux_2level_size50[50]->in[23] mux_2level_size50[50]->in[23] 0
+  0
***** Signal mux_2level_size50[50]->in[24] density = 0, probability=0.*****
Vmux_2level_size50[50]->in[24] mux_2level_size50[50]->in[24] 0
+  0
***** Signal mux_2level_size50[50]->in[25] density = 0, probability=0.*****
Vmux_2level_size50[50]->in[25] mux_2level_size50[50]->in[25] 0
+  0
***** Signal mux_2level_size50[50]->in[26] density = 0, probability=0.*****
Vmux_2level_size50[50]->in[26] mux_2level_size50[50]->in[26] 0
+  0
***** Signal mux_2level_size50[50]->in[27] density = 0, probability=0.*****
Vmux_2level_size50[50]->in[27] mux_2level_size50[50]->in[27] 0
+  0
***** Signal mux_2level_size50[50]->in[28] density = 0, probability=0.*****
Vmux_2level_size50[50]->in[28] mux_2level_size50[50]->in[28] 0
+  0
***** Signal mux_2level_size50[50]->in[29] density = 0, probability=0.*****
Vmux_2level_size50[50]->in[29] mux_2level_size50[50]->in[29] 0
+  0
***** Signal mux_2level_size50[50]->in[30] density = 0, probability=0.*****
Vmux_2level_size50[50]->in[30] mux_2level_size50[50]->in[30] 0
+  0
***** Signal mux_2level_size50[50]->in[31] density = 0, probability=0.*****
Vmux_2level_size50[50]->in[31] mux_2level_size50[50]->in[31] 0
+  0
***** Signal mux_2level_size50[50]->in[32] density = 0, probability=0.*****
Vmux_2level_size50[50]->in[32] mux_2level_size50[50]->in[32] 0
+  0
***** Signal mux_2level_size50[50]->in[33] density = 0, probability=0.*****
Vmux_2level_size50[50]->in[33] mux_2level_size50[50]->in[33] 0
+  0
***** Signal mux_2level_size50[50]->in[34] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[50]->in[34] mux_2level_size50[50]->in[34] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[50]->in[35] density = 0, probability=0.*****
Vmux_2level_size50[50]->in[35] mux_2level_size50[50]->in[35] 0
+  0
***** Signal mux_2level_size50[50]->in[36] density = 0, probability=0.*****
Vmux_2level_size50[50]->in[36] mux_2level_size50[50]->in[36] 0
+  0
***** Signal mux_2level_size50[50]->in[37] density = 0, probability=0.*****
Vmux_2level_size50[50]->in[37] mux_2level_size50[50]->in[37] 0
+  0
***** Signal mux_2level_size50[50]->in[38] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[50]->in[38] mux_2level_size50[50]->in[38] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[50]->in[39] density = 0, probability=0.*****
Vmux_2level_size50[50]->in[39] mux_2level_size50[50]->in[39] 0
+  0
***** Signal mux_2level_size50[50]->in[40] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[50]->in[40] mux_2level_size50[50]->in[40] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[50]->in[41] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[50]->in[41] mux_2level_size50[50]->in[41] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[50]->in[42] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[50]->in[42] mux_2level_size50[50]->in[42] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[50]->in[43] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[50]->in[43] mux_2level_size50[50]->in[43] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[50]->in[44] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[50]->in[44] mux_2level_size50[50]->in[44] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[50]->in[45] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[50]->in[45] mux_2level_size50[50]->in[45] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[50]->in[46] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[50]->in[46] mux_2level_size50[50]->in[46] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[50]->in[47] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[50]->in[47] mux_2level_size50[50]->in[47] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[50]->in[48] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[50]->in[48] mux_2level_size50[50]->in[48] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[50]->in[49] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[50]->in[49] mux_2level_size50[50]->in[49] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
Vgvdd_mux_2level_size50[50] gvdd_mux_2level_size50[50] 0 vsp
***** Measurements *****
***** Rise delay *****
.meas tran delay_rise_idle_mux50[50]_in[2]_crossbar trig v(mux_2level_size50[50]->in[0]) val='input_thres_pct_rise*vsp' rise=1 td='clock_period'
+          targ v(mux_2level_size50[50]->out) val='output_thres_pct_rise*vsp' rise=1 td='clock_period'
***** Fall delay *****
.meas tran delay_fall_idle_mux50[50]_in[2]_crossbar trig v(mux_2level_size50[50]->in[0]) val='input_thres_pct_fall*vsp' fall=1 td='clock_period'
+          targ v(mux_2level_size50[50]->out) val='output_thres_pct_fall*vsp' fall=1 td='clock_period'
***** Rise timing period *****
.meas start_rise_idle_mux50[50]_in[2]_crossbar when v(mux_2level_size50[50]->in[0])='slew_lower_thres_pct_rise*vsp' rise=1 td='clock_period'
.meas tran switch_rise_idle_mux50[50]_in[2]_crossbar trig v(mux_2level_size50[50]->in[0]) val='slew_lower_thres_pct_rise*vsp' rise=1 td='clock_period'
+          targ v(mux_2level_size50[50]->out) val='slew_upper_thres_pct_rise*vsp' rise=1 td='clock_period'
***** Fall timing period *****
.meas start_fall_idle_mux50[50]_in[2]_crossbar when v(mux_2level_size50[50]->in[0])='slew_lower_thres_pct_fall*vsp' fall=1 td='clock_period'
.meas tran switch_fall_idle_mux50[50]_in[2]_crossbar trig v(mux_2level_size50[50]->in[0]) val='slew_lower_thres_pct_fall*vsp' fall=1 td='clock_period'
+          targ v(mux_2level_size50[50]->out) val='slew_upper_thres_pct_fall*vsp' fall=1 td='clock_period'
***** Leakage Power Measurement *****
.meas tran mux_2level_size50[50]_leakage_power avg p(Vgvdd_mux_2level_size50[50]) from=0 to='clock_period'
.meas tran leakage_idle_mux50[50]_in[2]_crossbar param='mux_2level_size50[50]_leakage_power'
***** Dynamic Power Measurement *****
.meas tran mux_2level_size50[50]_dynamic_power avg p(Vgvdd_mux_2level_size50[50]) from='clock_period' to='6*clock_period'
.meas tran mux_2level_size50[50]_energy_per_cycle param='mux_2level_size50[50]_dynamic_power*clock_period'
.meas tran dynamic_power_idle_mux50[50]_in[2]_crossbar  param='mux_2level_size50[50]_dynamic_power'
.meas tran energy_per_cycle_idle_mux50[50]_in[2]_crossbar  param='dynamic_power_idle_mux50[50]_in[2]_crossbar*clock_period'
.meas tran dynamic_rise_idle_mux50[50]_in[2]_crossbar avg p(Vgvdd_mux_2level_size50[50]) from='start_rise_idle_mux50[50]_in[2]_crossbar' to='start_rise_idle_mux50[50]_in[2]_crossbar+switch_rise_idle_mux50[50]_in[2]_crossbar'
.meas tran dynamic_fall_idle_mux50[50]_in[2]_crossbar avg p(Vgvdd_mux_2level_size50[50]) from='start_fall_idle_mux50[50]_in[2]_crossbar' to='start_fall_idle_mux50[50]_in[2]_crossbar+switch_fall_idle_mux50[50]_in[2]_crossbar'
.meas tran sum_leakage_power_mux[0to50]
+          param='sum_leakage_power_mux[0to49]+leakage_idle_mux50[50]_in[2]_crossbar'
.meas tran sum_energy_per_cycle_mux[0to50]
+          param='sum_energy_per_cycle_mux[0to49]+energy_per_cycle_idle_mux50[50]_in[2]_crossbar'
Xload_inv[50]_no0 mux_2level_size50[50]->out mux_2level_size50[50]->out_out[0] gvdd_load 0 inv size=5
.meas tran sum_leakage_power_pb_mux[0to50]
+          param='sum_leakage_power_pb_mux[0to49]+leakage_idle_mux50[50]_in[2]_crossbar'
.meas tran sum_energy_per_cycle_pb_mux[0to50]
+          param='sum_energy_per_cycle_pb_mux[0to49]+energy_per_cycle_idle_mux50[50]_in[2]_crossbar'
Xmux_2level_size50[51] mux_2level_size50[51]->in[0] mux_2level_size50[51]->in[1] mux_2level_size50[51]->in[2] mux_2level_size50[51]->in[3] mux_2level_size50[51]->in[4] mux_2level_size50[51]->in[5] mux_2level_size50[51]->in[6] mux_2level_size50[51]->in[7] mux_2level_size50[51]->in[8] mux_2level_size50[51]->in[9] mux_2level_size50[51]->in[10] mux_2level_size50[51]->in[11] mux_2level_size50[51]->in[12] mux_2level_size50[51]->in[13] mux_2level_size50[51]->in[14] mux_2level_size50[51]->in[15] mux_2level_size50[51]->in[16] mux_2level_size50[51]->in[17] mux_2level_size50[51]->in[18] mux_2level_size50[51]->in[19] mux_2level_size50[51]->in[20] mux_2level_size50[51]->in[21] mux_2level_size50[51]->in[22] mux_2level_size50[51]->in[23] mux_2level_size50[51]->in[24] mux_2level_size50[51]->in[25] mux_2level_size50[51]->in[26] mux_2level_size50[51]->in[27] mux_2level_size50[51]->in[28] mux_2level_size50[51]->in[29] mux_2level_size50[51]->in[30] mux_2level_size50[51]->in[31] mux_2level_size50[51]->in[32] mux_2level_size50[51]->in[33] mux_2level_size50[51]->in[34] mux_2level_size50[51]->in[35] mux_2level_size50[51]->in[36] mux_2level_size50[51]->in[37] mux_2level_size50[51]->in[38] mux_2level_size50[51]->in[39] mux_2level_size50[51]->in[40] mux_2level_size50[51]->in[41] mux_2level_size50[51]->in[42] mux_2level_size50[51]->in[43] mux_2level_size50[51]->in[44] mux_2level_size50[51]->in[45] mux_2level_size50[51]->in[46] mux_2level_size50[51]->in[47] mux_2level_size50[51]->in[48] mux_2level_size50[51]->in[49] mux_2level_size50[51]->out sram[816]->outb sram[816]->out sram[817]->out sram[817]->outb sram[818]->out sram[818]->outb sram[819]->out sram[819]->outb sram[820]->out sram[820]->outb sram[821]->out sram[821]->outb sram[822]->out sram[822]->outb sram[823]->out sram[823]->outb sram[824]->outb sram[824]->out sram[825]->out sram[825]->outb sram[826]->out sram[826]->outb sram[827]->out sram[827]->outb sram[828]->out sram[828]->outb sram[829]->out sram[829]->outb sram[830]->out sram[830]->outb sram[831]->out sram[831]->outb gvdd_mux_2level_size50[51] 0 mux_2level_size50
***** SRAM bits for MUX[51], level=2, select_path_id=0. *****
*****1000000010000000*****
Xsram[816] sram->in sram[816]->out sram[816]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[816]->out) 0
.nodeset V(sram[816]->outb) vsp
Xsram[817] sram->in sram[817]->out sram[817]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[817]->out) 0
.nodeset V(sram[817]->outb) vsp
Xsram[818] sram->in sram[818]->out sram[818]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[818]->out) 0
.nodeset V(sram[818]->outb) vsp
Xsram[819] sram->in sram[819]->out sram[819]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[819]->out) 0
.nodeset V(sram[819]->outb) vsp
Xsram[820] sram->in sram[820]->out sram[820]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[820]->out) 0
.nodeset V(sram[820]->outb) vsp
Xsram[821] sram->in sram[821]->out sram[821]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[821]->out) 0
.nodeset V(sram[821]->outb) vsp
Xsram[822] sram->in sram[822]->out sram[822]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[822]->out) 0
.nodeset V(sram[822]->outb) vsp
Xsram[823] sram->in sram[823]->out sram[823]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[823]->out) 0
.nodeset V(sram[823]->outb) vsp
Xsram[824] sram->in sram[824]->out sram[824]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[824]->out) 0
.nodeset V(sram[824]->outb) vsp
Xsram[825] sram->in sram[825]->out sram[825]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[825]->out) 0
.nodeset V(sram[825]->outb) vsp
Xsram[826] sram->in sram[826]->out sram[826]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[826]->out) 0
.nodeset V(sram[826]->outb) vsp
Xsram[827] sram->in sram[827]->out sram[827]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[827]->out) 0
.nodeset V(sram[827]->outb) vsp
Xsram[828] sram->in sram[828]->out sram[828]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[828]->out) 0
.nodeset V(sram[828]->outb) vsp
Xsram[829] sram->in sram[829]->out sram[829]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[829]->out) 0
.nodeset V(sram[829]->outb) vsp
Xsram[830] sram->in sram[830]->out sram[830]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[830]->out) 0
.nodeset V(sram[830]->outb) vsp
Xsram[831] sram->in sram[831]->out sram[831]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[831]->out) 0
.nodeset V(sram[831]->outb) vsp
***** Signal mux_2level_size50[51]->in[0] density = 0, probability=0.*****
Vmux_2level_size50[51]->in[0] mux_2level_size50[51]->in[0] 0
+  0
***** Signal mux_2level_size50[51]->in[1] density = 0, probability=0.*****
Vmux_2level_size50[51]->in[1] mux_2level_size50[51]->in[1] 0
+  0
***** Signal mux_2level_size50[51]->in[2] density = 0, probability=0.*****
Vmux_2level_size50[51]->in[2] mux_2level_size50[51]->in[2] 0
+  0
***** Signal mux_2level_size50[51]->in[3] density = 0, probability=0.*****
Vmux_2level_size50[51]->in[3] mux_2level_size50[51]->in[3] 0
+  0
***** Signal mux_2level_size50[51]->in[4] density = 0, probability=0.*****
Vmux_2level_size50[51]->in[4] mux_2level_size50[51]->in[4] 0
+  0
***** Signal mux_2level_size50[51]->in[5] density = 0, probability=0.*****
Vmux_2level_size50[51]->in[5] mux_2level_size50[51]->in[5] 0
+  0
***** Signal mux_2level_size50[51]->in[6] density = 0, probability=0.*****
Vmux_2level_size50[51]->in[6] mux_2level_size50[51]->in[6] 0
+  0
***** Signal mux_2level_size50[51]->in[7] density = 0, probability=0.*****
Vmux_2level_size50[51]->in[7] mux_2level_size50[51]->in[7] 0
+  0
***** Signal mux_2level_size50[51]->in[8] density = 0, probability=0.*****
Vmux_2level_size50[51]->in[8] mux_2level_size50[51]->in[8] 0
+  0
***** Signal mux_2level_size50[51]->in[9] density = 0, probability=0.*****
Vmux_2level_size50[51]->in[9] mux_2level_size50[51]->in[9] 0
+  0
***** Signal mux_2level_size50[51]->in[10] density = 0, probability=0.*****
Vmux_2level_size50[51]->in[10] mux_2level_size50[51]->in[10] 0
+  0
***** Signal mux_2level_size50[51]->in[11] density = 0, probability=0.*****
Vmux_2level_size50[51]->in[11] mux_2level_size50[51]->in[11] 0
+  0
***** Signal mux_2level_size50[51]->in[12] density = 0, probability=0.*****
Vmux_2level_size50[51]->in[12] mux_2level_size50[51]->in[12] 0
+  0
***** Signal mux_2level_size50[51]->in[13] density = 0, probability=0.*****
Vmux_2level_size50[51]->in[13] mux_2level_size50[51]->in[13] 0
+  0
***** Signal mux_2level_size50[51]->in[14] density = 0, probability=0.*****
Vmux_2level_size50[51]->in[14] mux_2level_size50[51]->in[14] 0
+  0
***** Signal mux_2level_size50[51]->in[15] density = 0, probability=0.*****
Vmux_2level_size50[51]->in[15] mux_2level_size50[51]->in[15] 0
+  0
***** Signal mux_2level_size50[51]->in[16] density = 0, probability=0.*****
Vmux_2level_size50[51]->in[16] mux_2level_size50[51]->in[16] 0
+  0
***** Signal mux_2level_size50[51]->in[17] density = 0, probability=0.*****
Vmux_2level_size50[51]->in[17] mux_2level_size50[51]->in[17] 0
+  0
***** Signal mux_2level_size50[51]->in[18] density = 0, probability=0.*****
Vmux_2level_size50[51]->in[18] mux_2level_size50[51]->in[18] 0
+  0
***** Signal mux_2level_size50[51]->in[19] density = 0, probability=0.*****
Vmux_2level_size50[51]->in[19] mux_2level_size50[51]->in[19] 0
+  0
***** Signal mux_2level_size50[51]->in[20] density = 0, probability=0.*****
Vmux_2level_size50[51]->in[20] mux_2level_size50[51]->in[20] 0
+  0
***** Signal mux_2level_size50[51]->in[21] density = 0, probability=0.*****
Vmux_2level_size50[51]->in[21] mux_2level_size50[51]->in[21] 0
+  0
***** Signal mux_2level_size50[51]->in[22] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[51]->in[22] mux_2level_size50[51]->in[22] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[51]->in[23] density = 0, probability=0.*****
Vmux_2level_size50[51]->in[23] mux_2level_size50[51]->in[23] 0
+  0
***** Signal mux_2level_size50[51]->in[24] density = 0, probability=0.*****
Vmux_2level_size50[51]->in[24] mux_2level_size50[51]->in[24] 0
+  0
***** Signal mux_2level_size50[51]->in[25] density = 0, probability=0.*****
Vmux_2level_size50[51]->in[25] mux_2level_size50[51]->in[25] 0
+  0
***** Signal mux_2level_size50[51]->in[26] density = 0, probability=0.*****
Vmux_2level_size50[51]->in[26] mux_2level_size50[51]->in[26] 0
+  0
***** Signal mux_2level_size50[51]->in[27] density = 0, probability=0.*****
Vmux_2level_size50[51]->in[27] mux_2level_size50[51]->in[27] 0
+  0
***** Signal mux_2level_size50[51]->in[28] density = 0, probability=0.*****
Vmux_2level_size50[51]->in[28] mux_2level_size50[51]->in[28] 0
+  0
***** Signal mux_2level_size50[51]->in[29] density = 0, probability=0.*****
Vmux_2level_size50[51]->in[29] mux_2level_size50[51]->in[29] 0
+  0
***** Signal mux_2level_size50[51]->in[30] density = 0, probability=0.*****
Vmux_2level_size50[51]->in[30] mux_2level_size50[51]->in[30] 0
+  0
***** Signal mux_2level_size50[51]->in[31] density = 0, probability=0.*****
Vmux_2level_size50[51]->in[31] mux_2level_size50[51]->in[31] 0
+  0
***** Signal mux_2level_size50[51]->in[32] density = 0, probability=0.*****
Vmux_2level_size50[51]->in[32] mux_2level_size50[51]->in[32] 0
+  0
***** Signal mux_2level_size50[51]->in[33] density = 0, probability=0.*****
Vmux_2level_size50[51]->in[33] mux_2level_size50[51]->in[33] 0
+  0
***** Signal mux_2level_size50[51]->in[34] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[51]->in[34] mux_2level_size50[51]->in[34] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[51]->in[35] density = 0, probability=0.*****
Vmux_2level_size50[51]->in[35] mux_2level_size50[51]->in[35] 0
+  0
***** Signal mux_2level_size50[51]->in[36] density = 0, probability=0.*****
Vmux_2level_size50[51]->in[36] mux_2level_size50[51]->in[36] 0
+  0
***** Signal mux_2level_size50[51]->in[37] density = 0, probability=0.*****
Vmux_2level_size50[51]->in[37] mux_2level_size50[51]->in[37] 0
+  0
***** Signal mux_2level_size50[51]->in[38] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[51]->in[38] mux_2level_size50[51]->in[38] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[51]->in[39] density = 0, probability=0.*****
Vmux_2level_size50[51]->in[39] mux_2level_size50[51]->in[39] 0
+  0
***** Signal mux_2level_size50[51]->in[40] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[51]->in[40] mux_2level_size50[51]->in[40] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[51]->in[41] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[51]->in[41] mux_2level_size50[51]->in[41] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[51]->in[42] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[51]->in[42] mux_2level_size50[51]->in[42] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[51]->in[43] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[51]->in[43] mux_2level_size50[51]->in[43] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[51]->in[44] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[51]->in[44] mux_2level_size50[51]->in[44] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[51]->in[45] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[51]->in[45] mux_2level_size50[51]->in[45] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[51]->in[46] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[51]->in[46] mux_2level_size50[51]->in[46] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[51]->in[47] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[51]->in[47] mux_2level_size50[51]->in[47] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[51]->in[48] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[51]->in[48] mux_2level_size50[51]->in[48] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[51]->in[49] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[51]->in[49] mux_2level_size50[51]->in[49] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
Vgvdd_mux_2level_size50[51] gvdd_mux_2level_size50[51] 0 vsp
***** Measurements *****
***** Rise delay *****
.meas tran delay_rise_idle_mux50[51]_in[3]_crossbar trig v(mux_2level_size50[51]->in[0]) val='input_thres_pct_rise*vsp' rise=1 td='clock_period'
+          targ v(mux_2level_size50[51]->out) val='output_thres_pct_rise*vsp' rise=1 td='clock_period'
***** Fall delay *****
.meas tran delay_fall_idle_mux50[51]_in[3]_crossbar trig v(mux_2level_size50[51]->in[0]) val='input_thres_pct_fall*vsp' fall=1 td='clock_period'
+          targ v(mux_2level_size50[51]->out) val='output_thres_pct_fall*vsp' fall=1 td='clock_period'
***** Rise timing period *****
.meas start_rise_idle_mux50[51]_in[3]_crossbar when v(mux_2level_size50[51]->in[0])='slew_lower_thres_pct_rise*vsp' rise=1 td='clock_period'
.meas tran switch_rise_idle_mux50[51]_in[3]_crossbar trig v(mux_2level_size50[51]->in[0]) val='slew_lower_thres_pct_rise*vsp' rise=1 td='clock_period'
+          targ v(mux_2level_size50[51]->out) val='slew_upper_thres_pct_rise*vsp' rise=1 td='clock_period'
***** Fall timing period *****
.meas start_fall_idle_mux50[51]_in[3]_crossbar when v(mux_2level_size50[51]->in[0])='slew_lower_thres_pct_fall*vsp' fall=1 td='clock_period'
.meas tran switch_fall_idle_mux50[51]_in[3]_crossbar trig v(mux_2level_size50[51]->in[0]) val='slew_lower_thres_pct_fall*vsp' fall=1 td='clock_period'
+          targ v(mux_2level_size50[51]->out) val='slew_upper_thres_pct_fall*vsp' fall=1 td='clock_period'
***** Leakage Power Measurement *****
.meas tran mux_2level_size50[51]_leakage_power avg p(Vgvdd_mux_2level_size50[51]) from=0 to='clock_period'
.meas tran leakage_idle_mux50[51]_in[3]_crossbar param='mux_2level_size50[51]_leakage_power'
***** Dynamic Power Measurement *****
.meas tran mux_2level_size50[51]_dynamic_power avg p(Vgvdd_mux_2level_size50[51]) from='clock_period' to='6*clock_period'
.meas tran mux_2level_size50[51]_energy_per_cycle param='mux_2level_size50[51]_dynamic_power*clock_period'
.meas tran dynamic_power_idle_mux50[51]_in[3]_crossbar  param='mux_2level_size50[51]_dynamic_power'
.meas tran energy_per_cycle_idle_mux50[51]_in[3]_crossbar  param='dynamic_power_idle_mux50[51]_in[3]_crossbar*clock_period'
.meas tran dynamic_rise_idle_mux50[51]_in[3]_crossbar avg p(Vgvdd_mux_2level_size50[51]) from='start_rise_idle_mux50[51]_in[3]_crossbar' to='start_rise_idle_mux50[51]_in[3]_crossbar+switch_rise_idle_mux50[51]_in[3]_crossbar'
.meas tran dynamic_fall_idle_mux50[51]_in[3]_crossbar avg p(Vgvdd_mux_2level_size50[51]) from='start_fall_idle_mux50[51]_in[3]_crossbar' to='start_fall_idle_mux50[51]_in[3]_crossbar+switch_fall_idle_mux50[51]_in[3]_crossbar'
.meas tran sum_leakage_power_mux[0to51]
+          param='sum_leakage_power_mux[0to50]+leakage_idle_mux50[51]_in[3]_crossbar'
.meas tran sum_energy_per_cycle_mux[0to51]
+          param='sum_energy_per_cycle_mux[0to50]+energy_per_cycle_idle_mux50[51]_in[3]_crossbar'
Xload_inv[51]_no0 mux_2level_size50[51]->out mux_2level_size50[51]->out_out[0] gvdd_load 0 inv size=5
.meas tran sum_leakage_power_pb_mux[0to51]
+          param='sum_leakage_power_pb_mux[0to50]+leakage_idle_mux50[51]_in[3]_crossbar'
.meas tran sum_energy_per_cycle_pb_mux[0to51]
+          param='sum_energy_per_cycle_pb_mux[0to50]+energy_per_cycle_idle_mux50[51]_in[3]_crossbar'
Xmux_2level_size50[52] mux_2level_size50[52]->in[0] mux_2level_size50[52]->in[1] mux_2level_size50[52]->in[2] mux_2level_size50[52]->in[3] mux_2level_size50[52]->in[4] mux_2level_size50[52]->in[5] mux_2level_size50[52]->in[6] mux_2level_size50[52]->in[7] mux_2level_size50[52]->in[8] mux_2level_size50[52]->in[9] mux_2level_size50[52]->in[10] mux_2level_size50[52]->in[11] mux_2level_size50[52]->in[12] mux_2level_size50[52]->in[13] mux_2level_size50[52]->in[14] mux_2level_size50[52]->in[15] mux_2level_size50[52]->in[16] mux_2level_size50[52]->in[17] mux_2level_size50[52]->in[18] mux_2level_size50[52]->in[19] mux_2level_size50[52]->in[20] mux_2level_size50[52]->in[21] mux_2level_size50[52]->in[22] mux_2level_size50[52]->in[23] mux_2level_size50[52]->in[24] mux_2level_size50[52]->in[25] mux_2level_size50[52]->in[26] mux_2level_size50[52]->in[27] mux_2level_size50[52]->in[28] mux_2level_size50[52]->in[29] mux_2level_size50[52]->in[30] mux_2level_size50[52]->in[31] mux_2level_size50[52]->in[32] mux_2level_size50[52]->in[33] mux_2level_size50[52]->in[34] mux_2level_size50[52]->in[35] mux_2level_size50[52]->in[36] mux_2level_size50[52]->in[37] mux_2level_size50[52]->in[38] mux_2level_size50[52]->in[39] mux_2level_size50[52]->in[40] mux_2level_size50[52]->in[41] mux_2level_size50[52]->in[42] mux_2level_size50[52]->in[43] mux_2level_size50[52]->in[44] mux_2level_size50[52]->in[45] mux_2level_size50[52]->in[46] mux_2level_size50[52]->in[47] mux_2level_size50[52]->in[48] mux_2level_size50[52]->in[49] mux_2level_size50[52]->out sram[832]->outb sram[832]->out sram[833]->out sram[833]->outb sram[834]->out sram[834]->outb sram[835]->out sram[835]->outb sram[836]->out sram[836]->outb sram[837]->out sram[837]->outb sram[838]->out sram[838]->outb sram[839]->out sram[839]->outb sram[840]->outb sram[840]->out sram[841]->out sram[841]->outb sram[842]->out sram[842]->outb sram[843]->out sram[843]->outb sram[844]->out sram[844]->outb sram[845]->out sram[845]->outb sram[846]->out sram[846]->outb sram[847]->out sram[847]->outb gvdd_mux_2level_size50[52] 0 mux_2level_size50
***** SRAM bits for MUX[52], level=2, select_path_id=0. *****
*****1000000010000000*****
Xsram[832] sram->in sram[832]->out sram[832]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[832]->out) 0
.nodeset V(sram[832]->outb) vsp
Xsram[833] sram->in sram[833]->out sram[833]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[833]->out) 0
.nodeset V(sram[833]->outb) vsp
Xsram[834] sram->in sram[834]->out sram[834]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[834]->out) 0
.nodeset V(sram[834]->outb) vsp
Xsram[835] sram->in sram[835]->out sram[835]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[835]->out) 0
.nodeset V(sram[835]->outb) vsp
Xsram[836] sram->in sram[836]->out sram[836]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[836]->out) 0
.nodeset V(sram[836]->outb) vsp
Xsram[837] sram->in sram[837]->out sram[837]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[837]->out) 0
.nodeset V(sram[837]->outb) vsp
Xsram[838] sram->in sram[838]->out sram[838]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[838]->out) 0
.nodeset V(sram[838]->outb) vsp
Xsram[839] sram->in sram[839]->out sram[839]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[839]->out) 0
.nodeset V(sram[839]->outb) vsp
Xsram[840] sram->in sram[840]->out sram[840]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[840]->out) 0
.nodeset V(sram[840]->outb) vsp
Xsram[841] sram->in sram[841]->out sram[841]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[841]->out) 0
.nodeset V(sram[841]->outb) vsp
Xsram[842] sram->in sram[842]->out sram[842]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[842]->out) 0
.nodeset V(sram[842]->outb) vsp
Xsram[843] sram->in sram[843]->out sram[843]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[843]->out) 0
.nodeset V(sram[843]->outb) vsp
Xsram[844] sram->in sram[844]->out sram[844]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[844]->out) 0
.nodeset V(sram[844]->outb) vsp
Xsram[845] sram->in sram[845]->out sram[845]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[845]->out) 0
.nodeset V(sram[845]->outb) vsp
Xsram[846] sram->in sram[846]->out sram[846]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[846]->out) 0
.nodeset V(sram[846]->outb) vsp
Xsram[847] sram->in sram[847]->out sram[847]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[847]->out) 0
.nodeset V(sram[847]->outb) vsp
***** Signal mux_2level_size50[52]->in[0] density = 0, probability=0.*****
Vmux_2level_size50[52]->in[0] mux_2level_size50[52]->in[0] 0
+  0
***** Signal mux_2level_size50[52]->in[1] density = 0, probability=0.*****
Vmux_2level_size50[52]->in[1] mux_2level_size50[52]->in[1] 0
+  0
***** Signal mux_2level_size50[52]->in[2] density = 0, probability=0.*****
Vmux_2level_size50[52]->in[2] mux_2level_size50[52]->in[2] 0
+  0
***** Signal mux_2level_size50[52]->in[3] density = 0, probability=0.*****
Vmux_2level_size50[52]->in[3] mux_2level_size50[52]->in[3] 0
+  0
***** Signal mux_2level_size50[52]->in[4] density = 0, probability=0.*****
Vmux_2level_size50[52]->in[4] mux_2level_size50[52]->in[4] 0
+  0
***** Signal mux_2level_size50[52]->in[5] density = 0, probability=0.*****
Vmux_2level_size50[52]->in[5] mux_2level_size50[52]->in[5] 0
+  0
***** Signal mux_2level_size50[52]->in[6] density = 0, probability=0.*****
Vmux_2level_size50[52]->in[6] mux_2level_size50[52]->in[6] 0
+  0
***** Signal mux_2level_size50[52]->in[7] density = 0, probability=0.*****
Vmux_2level_size50[52]->in[7] mux_2level_size50[52]->in[7] 0
+  0
***** Signal mux_2level_size50[52]->in[8] density = 0, probability=0.*****
Vmux_2level_size50[52]->in[8] mux_2level_size50[52]->in[8] 0
+  0
***** Signal mux_2level_size50[52]->in[9] density = 0, probability=0.*****
Vmux_2level_size50[52]->in[9] mux_2level_size50[52]->in[9] 0
+  0
***** Signal mux_2level_size50[52]->in[10] density = 0, probability=0.*****
Vmux_2level_size50[52]->in[10] mux_2level_size50[52]->in[10] 0
+  0
***** Signal mux_2level_size50[52]->in[11] density = 0, probability=0.*****
Vmux_2level_size50[52]->in[11] mux_2level_size50[52]->in[11] 0
+  0
***** Signal mux_2level_size50[52]->in[12] density = 0, probability=0.*****
Vmux_2level_size50[52]->in[12] mux_2level_size50[52]->in[12] 0
+  0
***** Signal mux_2level_size50[52]->in[13] density = 0, probability=0.*****
Vmux_2level_size50[52]->in[13] mux_2level_size50[52]->in[13] 0
+  0
***** Signal mux_2level_size50[52]->in[14] density = 0, probability=0.*****
Vmux_2level_size50[52]->in[14] mux_2level_size50[52]->in[14] 0
+  0
***** Signal mux_2level_size50[52]->in[15] density = 0, probability=0.*****
Vmux_2level_size50[52]->in[15] mux_2level_size50[52]->in[15] 0
+  0
***** Signal mux_2level_size50[52]->in[16] density = 0, probability=0.*****
Vmux_2level_size50[52]->in[16] mux_2level_size50[52]->in[16] 0
+  0
***** Signal mux_2level_size50[52]->in[17] density = 0, probability=0.*****
Vmux_2level_size50[52]->in[17] mux_2level_size50[52]->in[17] 0
+  0
***** Signal mux_2level_size50[52]->in[18] density = 0, probability=0.*****
Vmux_2level_size50[52]->in[18] mux_2level_size50[52]->in[18] 0
+  0
***** Signal mux_2level_size50[52]->in[19] density = 0, probability=0.*****
Vmux_2level_size50[52]->in[19] mux_2level_size50[52]->in[19] 0
+  0
***** Signal mux_2level_size50[52]->in[20] density = 0, probability=0.*****
Vmux_2level_size50[52]->in[20] mux_2level_size50[52]->in[20] 0
+  0
***** Signal mux_2level_size50[52]->in[21] density = 0, probability=0.*****
Vmux_2level_size50[52]->in[21] mux_2level_size50[52]->in[21] 0
+  0
***** Signal mux_2level_size50[52]->in[22] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[52]->in[22] mux_2level_size50[52]->in[22] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[52]->in[23] density = 0, probability=0.*****
Vmux_2level_size50[52]->in[23] mux_2level_size50[52]->in[23] 0
+  0
***** Signal mux_2level_size50[52]->in[24] density = 0, probability=0.*****
Vmux_2level_size50[52]->in[24] mux_2level_size50[52]->in[24] 0
+  0
***** Signal mux_2level_size50[52]->in[25] density = 0, probability=0.*****
Vmux_2level_size50[52]->in[25] mux_2level_size50[52]->in[25] 0
+  0
***** Signal mux_2level_size50[52]->in[26] density = 0, probability=0.*****
Vmux_2level_size50[52]->in[26] mux_2level_size50[52]->in[26] 0
+  0
***** Signal mux_2level_size50[52]->in[27] density = 0, probability=0.*****
Vmux_2level_size50[52]->in[27] mux_2level_size50[52]->in[27] 0
+  0
***** Signal mux_2level_size50[52]->in[28] density = 0, probability=0.*****
Vmux_2level_size50[52]->in[28] mux_2level_size50[52]->in[28] 0
+  0
***** Signal mux_2level_size50[52]->in[29] density = 0, probability=0.*****
Vmux_2level_size50[52]->in[29] mux_2level_size50[52]->in[29] 0
+  0
***** Signal mux_2level_size50[52]->in[30] density = 0, probability=0.*****
Vmux_2level_size50[52]->in[30] mux_2level_size50[52]->in[30] 0
+  0
***** Signal mux_2level_size50[52]->in[31] density = 0, probability=0.*****
Vmux_2level_size50[52]->in[31] mux_2level_size50[52]->in[31] 0
+  0
***** Signal mux_2level_size50[52]->in[32] density = 0, probability=0.*****
Vmux_2level_size50[52]->in[32] mux_2level_size50[52]->in[32] 0
+  0
***** Signal mux_2level_size50[52]->in[33] density = 0, probability=0.*****
Vmux_2level_size50[52]->in[33] mux_2level_size50[52]->in[33] 0
+  0
***** Signal mux_2level_size50[52]->in[34] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[52]->in[34] mux_2level_size50[52]->in[34] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[52]->in[35] density = 0, probability=0.*****
Vmux_2level_size50[52]->in[35] mux_2level_size50[52]->in[35] 0
+  0
***** Signal mux_2level_size50[52]->in[36] density = 0, probability=0.*****
Vmux_2level_size50[52]->in[36] mux_2level_size50[52]->in[36] 0
+  0
***** Signal mux_2level_size50[52]->in[37] density = 0, probability=0.*****
Vmux_2level_size50[52]->in[37] mux_2level_size50[52]->in[37] 0
+  0
***** Signal mux_2level_size50[52]->in[38] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[52]->in[38] mux_2level_size50[52]->in[38] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[52]->in[39] density = 0, probability=0.*****
Vmux_2level_size50[52]->in[39] mux_2level_size50[52]->in[39] 0
+  0
***** Signal mux_2level_size50[52]->in[40] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[52]->in[40] mux_2level_size50[52]->in[40] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[52]->in[41] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[52]->in[41] mux_2level_size50[52]->in[41] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[52]->in[42] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[52]->in[42] mux_2level_size50[52]->in[42] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[52]->in[43] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[52]->in[43] mux_2level_size50[52]->in[43] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[52]->in[44] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[52]->in[44] mux_2level_size50[52]->in[44] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[52]->in[45] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[52]->in[45] mux_2level_size50[52]->in[45] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[52]->in[46] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[52]->in[46] mux_2level_size50[52]->in[46] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[52]->in[47] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[52]->in[47] mux_2level_size50[52]->in[47] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[52]->in[48] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[52]->in[48] mux_2level_size50[52]->in[48] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[52]->in[49] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[52]->in[49] mux_2level_size50[52]->in[49] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
Vgvdd_mux_2level_size50[52] gvdd_mux_2level_size50[52] 0 vsp
***** Measurements *****
***** Rise delay *****
.meas tran delay_rise_idle_mux50[52]_in[4]_crossbar trig v(mux_2level_size50[52]->in[0]) val='input_thres_pct_rise*vsp' rise=1 td='clock_period'
+          targ v(mux_2level_size50[52]->out) val='output_thres_pct_rise*vsp' rise=1 td='clock_period'
***** Fall delay *****
.meas tran delay_fall_idle_mux50[52]_in[4]_crossbar trig v(mux_2level_size50[52]->in[0]) val='input_thres_pct_fall*vsp' fall=1 td='clock_period'
+          targ v(mux_2level_size50[52]->out) val='output_thres_pct_fall*vsp' fall=1 td='clock_period'
***** Rise timing period *****
.meas start_rise_idle_mux50[52]_in[4]_crossbar when v(mux_2level_size50[52]->in[0])='slew_lower_thres_pct_rise*vsp' rise=1 td='clock_period'
.meas tran switch_rise_idle_mux50[52]_in[4]_crossbar trig v(mux_2level_size50[52]->in[0]) val='slew_lower_thres_pct_rise*vsp' rise=1 td='clock_period'
+          targ v(mux_2level_size50[52]->out) val='slew_upper_thres_pct_rise*vsp' rise=1 td='clock_period'
***** Fall timing period *****
.meas start_fall_idle_mux50[52]_in[4]_crossbar when v(mux_2level_size50[52]->in[0])='slew_lower_thres_pct_fall*vsp' fall=1 td='clock_period'
.meas tran switch_fall_idle_mux50[52]_in[4]_crossbar trig v(mux_2level_size50[52]->in[0]) val='slew_lower_thres_pct_fall*vsp' fall=1 td='clock_period'
+          targ v(mux_2level_size50[52]->out) val='slew_upper_thres_pct_fall*vsp' fall=1 td='clock_period'
***** Leakage Power Measurement *****
.meas tran mux_2level_size50[52]_leakage_power avg p(Vgvdd_mux_2level_size50[52]) from=0 to='clock_period'
.meas tran leakage_idle_mux50[52]_in[4]_crossbar param='mux_2level_size50[52]_leakage_power'
***** Dynamic Power Measurement *****
.meas tran mux_2level_size50[52]_dynamic_power avg p(Vgvdd_mux_2level_size50[52]) from='clock_period' to='6*clock_period'
.meas tran mux_2level_size50[52]_energy_per_cycle param='mux_2level_size50[52]_dynamic_power*clock_period'
.meas tran dynamic_power_idle_mux50[52]_in[4]_crossbar  param='mux_2level_size50[52]_dynamic_power'
.meas tran energy_per_cycle_idle_mux50[52]_in[4]_crossbar  param='dynamic_power_idle_mux50[52]_in[4]_crossbar*clock_period'
.meas tran dynamic_rise_idle_mux50[52]_in[4]_crossbar avg p(Vgvdd_mux_2level_size50[52]) from='start_rise_idle_mux50[52]_in[4]_crossbar' to='start_rise_idle_mux50[52]_in[4]_crossbar+switch_rise_idle_mux50[52]_in[4]_crossbar'
.meas tran dynamic_fall_idle_mux50[52]_in[4]_crossbar avg p(Vgvdd_mux_2level_size50[52]) from='start_fall_idle_mux50[52]_in[4]_crossbar' to='start_fall_idle_mux50[52]_in[4]_crossbar+switch_fall_idle_mux50[52]_in[4]_crossbar'
.meas tran sum_leakage_power_mux[0to52]
+          param='sum_leakage_power_mux[0to51]+leakage_idle_mux50[52]_in[4]_crossbar'
.meas tran sum_energy_per_cycle_mux[0to52]
+          param='sum_energy_per_cycle_mux[0to51]+energy_per_cycle_idle_mux50[52]_in[4]_crossbar'
Xload_inv[52]_no0 mux_2level_size50[52]->out mux_2level_size50[52]->out_out[0] gvdd_load 0 inv size=5
.meas tran sum_leakage_power_pb_mux[0to52]
+          param='sum_leakage_power_pb_mux[0to51]+leakage_idle_mux50[52]_in[4]_crossbar'
.meas tran sum_energy_per_cycle_pb_mux[0to52]
+          param='sum_energy_per_cycle_pb_mux[0to51]+energy_per_cycle_idle_mux50[52]_in[4]_crossbar'
Xmux_2level_size50[53] mux_2level_size50[53]->in[0] mux_2level_size50[53]->in[1] mux_2level_size50[53]->in[2] mux_2level_size50[53]->in[3] mux_2level_size50[53]->in[4] mux_2level_size50[53]->in[5] mux_2level_size50[53]->in[6] mux_2level_size50[53]->in[7] mux_2level_size50[53]->in[8] mux_2level_size50[53]->in[9] mux_2level_size50[53]->in[10] mux_2level_size50[53]->in[11] mux_2level_size50[53]->in[12] mux_2level_size50[53]->in[13] mux_2level_size50[53]->in[14] mux_2level_size50[53]->in[15] mux_2level_size50[53]->in[16] mux_2level_size50[53]->in[17] mux_2level_size50[53]->in[18] mux_2level_size50[53]->in[19] mux_2level_size50[53]->in[20] mux_2level_size50[53]->in[21] mux_2level_size50[53]->in[22] mux_2level_size50[53]->in[23] mux_2level_size50[53]->in[24] mux_2level_size50[53]->in[25] mux_2level_size50[53]->in[26] mux_2level_size50[53]->in[27] mux_2level_size50[53]->in[28] mux_2level_size50[53]->in[29] mux_2level_size50[53]->in[30] mux_2level_size50[53]->in[31] mux_2level_size50[53]->in[32] mux_2level_size50[53]->in[33] mux_2level_size50[53]->in[34] mux_2level_size50[53]->in[35] mux_2level_size50[53]->in[36] mux_2level_size50[53]->in[37] mux_2level_size50[53]->in[38] mux_2level_size50[53]->in[39] mux_2level_size50[53]->in[40] mux_2level_size50[53]->in[41] mux_2level_size50[53]->in[42] mux_2level_size50[53]->in[43] mux_2level_size50[53]->in[44] mux_2level_size50[53]->in[45] mux_2level_size50[53]->in[46] mux_2level_size50[53]->in[47] mux_2level_size50[53]->in[48] mux_2level_size50[53]->in[49] mux_2level_size50[53]->out sram[848]->outb sram[848]->out sram[849]->out sram[849]->outb sram[850]->out sram[850]->outb sram[851]->out sram[851]->outb sram[852]->out sram[852]->outb sram[853]->out sram[853]->outb sram[854]->out sram[854]->outb sram[855]->out sram[855]->outb sram[856]->outb sram[856]->out sram[857]->out sram[857]->outb sram[858]->out sram[858]->outb sram[859]->out sram[859]->outb sram[860]->out sram[860]->outb sram[861]->out sram[861]->outb sram[862]->out sram[862]->outb sram[863]->out sram[863]->outb gvdd_mux_2level_size50[53] 0 mux_2level_size50
***** SRAM bits for MUX[53], level=2, select_path_id=0. *****
*****1000000010000000*****
Xsram[848] sram->in sram[848]->out sram[848]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[848]->out) 0
.nodeset V(sram[848]->outb) vsp
Xsram[849] sram->in sram[849]->out sram[849]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[849]->out) 0
.nodeset V(sram[849]->outb) vsp
Xsram[850] sram->in sram[850]->out sram[850]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[850]->out) 0
.nodeset V(sram[850]->outb) vsp
Xsram[851] sram->in sram[851]->out sram[851]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[851]->out) 0
.nodeset V(sram[851]->outb) vsp
Xsram[852] sram->in sram[852]->out sram[852]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[852]->out) 0
.nodeset V(sram[852]->outb) vsp
Xsram[853] sram->in sram[853]->out sram[853]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[853]->out) 0
.nodeset V(sram[853]->outb) vsp
Xsram[854] sram->in sram[854]->out sram[854]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[854]->out) 0
.nodeset V(sram[854]->outb) vsp
Xsram[855] sram->in sram[855]->out sram[855]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[855]->out) 0
.nodeset V(sram[855]->outb) vsp
Xsram[856] sram->in sram[856]->out sram[856]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[856]->out) 0
.nodeset V(sram[856]->outb) vsp
Xsram[857] sram->in sram[857]->out sram[857]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[857]->out) 0
.nodeset V(sram[857]->outb) vsp
Xsram[858] sram->in sram[858]->out sram[858]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[858]->out) 0
.nodeset V(sram[858]->outb) vsp
Xsram[859] sram->in sram[859]->out sram[859]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[859]->out) 0
.nodeset V(sram[859]->outb) vsp
Xsram[860] sram->in sram[860]->out sram[860]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[860]->out) 0
.nodeset V(sram[860]->outb) vsp
Xsram[861] sram->in sram[861]->out sram[861]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[861]->out) 0
.nodeset V(sram[861]->outb) vsp
Xsram[862] sram->in sram[862]->out sram[862]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[862]->out) 0
.nodeset V(sram[862]->outb) vsp
Xsram[863] sram->in sram[863]->out sram[863]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[863]->out) 0
.nodeset V(sram[863]->outb) vsp
***** Signal mux_2level_size50[53]->in[0] density = 0, probability=0.*****
Vmux_2level_size50[53]->in[0] mux_2level_size50[53]->in[0] 0
+  0
***** Signal mux_2level_size50[53]->in[1] density = 0, probability=0.*****
Vmux_2level_size50[53]->in[1] mux_2level_size50[53]->in[1] 0
+  0
***** Signal mux_2level_size50[53]->in[2] density = 0, probability=0.*****
Vmux_2level_size50[53]->in[2] mux_2level_size50[53]->in[2] 0
+  0
***** Signal mux_2level_size50[53]->in[3] density = 0, probability=0.*****
Vmux_2level_size50[53]->in[3] mux_2level_size50[53]->in[3] 0
+  0
***** Signal mux_2level_size50[53]->in[4] density = 0, probability=0.*****
Vmux_2level_size50[53]->in[4] mux_2level_size50[53]->in[4] 0
+  0
***** Signal mux_2level_size50[53]->in[5] density = 0, probability=0.*****
Vmux_2level_size50[53]->in[5] mux_2level_size50[53]->in[5] 0
+  0
***** Signal mux_2level_size50[53]->in[6] density = 0, probability=0.*****
Vmux_2level_size50[53]->in[6] mux_2level_size50[53]->in[6] 0
+  0
***** Signal mux_2level_size50[53]->in[7] density = 0, probability=0.*****
Vmux_2level_size50[53]->in[7] mux_2level_size50[53]->in[7] 0
+  0
***** Signal mux_2level_size50[53]->in[8] density = 0, probability=0.*****
Vmux_2level_size50[53]->in[8] mux_2level_size50[53]->in[8] 0
+  0
***** Signal mux_2level_size50[53]->in[9] density = 0, probability=0.*****
Vmux_2level_size50[53]->in[9] mux_2level_size50[53]->in[9] 0
+  0
***** Signal mux_2level_size50[53]->in[10] density = 0, probability=0.*****
Vmux_2level_size50[53]->in[10] mux_2level_size50[53]->in[10] 0
+  0
***** Signal mux_2level_size50[53]->in[11] density = 0, probability=0.*****
Vmux_2level_size50[53]->in[11] mux_2level_size50[53]->in[11] 0
+  0
***** Signal mux_2level_size50[53]->in[12] density = 0, probability=0.*****
Vmux_2level_size50[53]->in[12] mux_2level_size50[53]->in[12] 0
+  0
***** Signal mux_2level_size50[53]->in[13] density = 0, probability=0.*****
Vmux_2level_size50[53]->in[13] mux_2level_size50[53]->in[13] 0
+  0
***** Signal mux_2level_size50[53]->in[14] density = 0, probability=0.*****
Vmux_2level_size50[53]->in[14] mux_2level_size50[53]->in[14] 0
+  0
***** Signal mux_2level_size50[53]->in[15] density = 0, probability=0.*****
Vmux_2level_size50[53]->in[15] mux_2level_size50[53]->in[15] 0
+  0
***** Signal mux_2level_size50[53]->in[16] density = 0, probability=0.*****
Vmux_2level_size50[53]->in[16] mux_2level_size50[53]->in[16] 0
+  0
***** Signal mux_2level_size50[53]->in[17] density = 0, probability=0.*****
Vmux_2level_size50[53]->in[17] mux_2level_size50[53]->in[17] 0
+  0
***** Signal mux_2level_size50[53]->in[18] density = 0, probability=0.*****
Vmux_2level_size50[53]->in[18] mux_2level_size50[53]->in[18] 0
+  0
***** Signal mux_2level_size50[53]->in[19] density = 0, probability=0.*****
Vmux_2level_size50[53]->in[19] mux_2level_size50[53]->in[19] 0
+  0
***** Signal mux_2level_size50[53]->in[20] density = 0, probability=0.*****
Vmux_2level_size50[53]->in[20] mux_2level_size50[53]->in[20] 0
+  0
***** Signal mux_2level_size50[53]->in[21] density = 0, probability=0.*****
Vmux_2level_size50[53]->in[21] mux_2level_size50[53]->in[21] 0
+  0
***** Signal mux_2level_size50[53]->in[22] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[53]->in[22] mux_2level_size50[53]->in[22] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[53]->in[23] density = 0, probability=0.*****
Vmux_2level_size50[53]->in[23] mux_2level_size50[53]->in[23] 0
+  0
***** Signal mux_2level_size50[53]->in[24] density = 0, probability=0.*****
Vmux_2level_size50[53]->in[24] mux_2level_size50[53]->in[24] 0
+  0
***** Signal mux_2level_size50[53]->in[25] density = 0, probability=0.*****
Vmux_2level_size50[53]->in[25] mux_2level_size50[53]->in[25] 0
+  0
***** Signal mux_2level_size50[53]->in[26] density = 0, probability=0.*****
Vmux_2level_size50[53]->in[26] mux_2level_size50[53]->in[26] 0
+  0
***** Signal mux_2level_size50[53]->in[27] density = 0, probability=0.*****
Vmux_2level_size50[53]->in[27] mux_2level_size50[53]->in[27] 0
+  0
***** Signal mux_2level_size50[53]->in[28] density = 0, probability=0.*****
Vmux_2level_size50[53]->in[28] mux_2level_size50[53]->in[28] 0
+  0
***** Signal mux_2level_size50[53]->in[29] density = 0, probability=0.*****
Vmux_2level_size50[53]->in[29] mux_2level_size50[53]->in[29] 0
+  0
***** Signal mux_2level_size50[53]->in[30] density = 0, probability=0.*****
Vmux_2level_size50[53]->in[30] mux_2level_size50[53]->in[30] 0
+  0
***** Signal mux_2level_size50[53]->in[31] density = 0, probability=0.*****
Vmux_2level_size50[53]->in[31] mux_2level_size50[53]->in[31] 0
+  0
***** Signal mux_2level_size50[53]->in[32] density = 0, probability=0.*****
Vmux_2level_size50[53]->in[32] mux_2level_size50[53]->in[32] 0
+  0
***** Signal mux_2level_size50[53]->in[33] density = 0, probability=0.*****
Vmux_2level_size50[53]->in[33] mux_2level_size50[53]->in[33] 0
+  0
***** Signal mux_2level_size50[53]->in[34] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[53]->in[34] mux_2level_size50[53]->in[34] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[53]->in[35] density = 0, probability=0.*****
Vmux_2level_size50[53]->in[35] mux_2level_size50[53]->in[35] 0
+  0
***** Signal mux_2level_size50[53]->in[36] density = 0, probability=0.*****
Vmux_2level_size50[53]->in[36] mux_2level_size50[53]->in[36] 0
+  0
***** Signal mux_2level_size50[53]->in[37] density = 0, probability=0.*****
Vmux_2level_size50[53]->in[37] mux_2level_size50[53]->in[37] 0
+  0
***** Signal mux_2level_size50[53]->in[38] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[53]->in[38] mux_2level_size50[53]->in[38] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[53]->in[39] density = 0, probability=0.*****
Vmux_2level_size50[53]->in[39] mux_2level_size50[53]->in[39] 0
+  0
***** Signal mux_2level_size50[53]->in[40] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[53]->in[40] mux_2level_size50[53]->in[40] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[53]->in[41] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[53]->in[41] mux_2level_size50[53]->in[41] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[53]->in[42] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[53]->in[42] mux_2level_size50[53]->in[42] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[53]->in[43] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[53]->in[43] mux_2level_size50[53]->in[43] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[53]->in[44] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[53]->in[44] mux_2level_size50[53]->in[44] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[53]->in[45] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[53]->in[45] mux_2level_size50[53]->in[45] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[53]->in[46] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[53]->in[46] mux_2level_size50[53]->in[46] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[53]->in[47] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[53]->in[47] mux_2level_size50[53]->in[47] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[53]->in[48] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[53]->in[48] mux_2level_size50[53]->in[48] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[53]->in[49] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[53]->in[49] mux_2level_size50[53]->in[49] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
Vgvdd_mux_2level_size50[53] gvdd_mux_2level_size50[53] 0 vsp
***** Measurements *****
***** Rise delay *****
.meas tran delay_rise_idle_mux50[53]_in[5]_crossbar trig v(mux_2level_size50[53]->in[0]) val='input_thres_pct_rise*vsp' rise=1 td='clock_period'
+          targ v(mux_2level_size50[53]->out) val='output_thres_pct_rise*vsp' rise=1 td='clock_period'
***** Fall delay *****
.meas tran delay_fall_idle_mux50[53]_in[5]_crossbar trig v(mux_2level_size50[53]->in[0]) val='input_thres_pct_fall*vsp' fall=1 td='clock_period'
+          targ v(mux_2level_size50[53]->out) val='output_thres_pct_fall*vsp' fall=1 td='clock_period'
***** Rise timing period *****
.meas start_rise_idle_mux50[53]_in[5]_crossbar when v(mux_2level_size50[53]->in[0])='slew_lower_thres_pct_rise*vsp' rise=1 td='clock_period'
.meas tran switch_rise_idle_mux50[53]_in[5]_crossbar trig v(mux_2level_size50[53]->in[0]) val='slew_lower_thres_pct_rise*vsp' rise=1 td='clock_period'
+          targ v(mux_2level_size50[53]->out) val='slew_upper_thres_pct_rise*vsp' rise=1 td='clock_period'
***** Fall timing period *****
.meas start_fall_idle_mux50[53]_in[5]_crossbar when v(mux_2level_size50[53]->in[0])='slew_lower_thres_pct_fall*vsp' fall=1 td='clock_period'
.meas tran switch_fall_idle_mux50[53]_in[5]_crossbar trig v(mux_2level_size50[53]->in[0]) val='slew_lower_thres_pct_fall*vsp' fall=1 td='clock_period'
+          targ v(mux_2level_size50[53]->out) val='slew_upper_thres_pct_fall*vsp' fall=1 td='clock_period'
***** Leakage Power Measurement *****
.meas tran mux_2level_size50[53]_leakage_power avg p(Vgvdd_mux_2level_size50[53]) from=0 to='clock_period'
.meas tran leakage_idle_mux50[53]_in[5]_crossbar param='mux_2level_size50[53]_leakage_power'
***** Dynamic Power Measurement *****
.meas tran mux_2level_size50[53]_dynamic_power avg p(Vgvdd_mux_2level_size50[53]) from='clock_period' to='6*clock_period'
.meas tran mux_2level_size50[53]_energy_per_cycle param='mux_2level_size50[53]_dynamic_power*clock_period'
.meas tran dynamic_power_idle_mux50[53]_in[5]_crossbar  param='mux_2level_size50[53]_dynamic_power'
.meas tran energy_per_cycle_idle_mux50[53]_in[5]_crossbar  param='dynamic_power_idle_mux50[53]_in[5]_crossbar*clock_period'
.meas tran dynamic_rise_idle_mux50[53]_in[5]_crossbar avg p(Vgvdd_mux_2level_size50[53]) from='start_rise_idle_mux50[53]_in[5]_crossbar' to='start_rise_idle_mux50[53]_in[5]_crossbar+switch_rise_idle_mux50[53]_in[5]_crossbar'
.meas tran dynamic_fall_idle_mux50[53]_in[5]_crossbar avg p(Vgvdd_mux_2level_size50[53]) from='start_fall_idle_mux50[53]_in[5]_crossbar' to='start_fall_idle_mux50[53]_in[5]_crossbar+switch_fall_idle_mux50[53]_in[5]_crossbar'
.meas tran sum_leakage_power_mux[0to53]
+          param='sum_leakage_power_mux[0to52]+leakage_idle_mux50[53]_in[5]_crossbar'
.meas tran sum_energy_per_cycle_mux[0to53]
+          param='sum_energy_per_cycle_mux[0to52]+energy_per_cycle_idle_mux50[53]_in[5]_crossbar'
Xload_inv[53]_no0 mux_2level_size50[53]->out mux_2level_size50[53]->out_out[0] gvdd_load 0 inv size=5
.meas tran sum_leakage_power_pb_mux[0to53]
+          param='sum_leakage_power_pb_mux[0to52]+leakage_idle_mux50[53]_in[5]_crossbar'
.meas tran sum_energy_per_cycle_pb_mux[0to53]
+          param='sum_energy_per_cycle_pb_mux[0to52]+energy_per_cycle_idle_mux50[53]_in[5]_crossbar'
Xmux_2level_size50[54] mux_2level_size50[54]->in[0] mux_2level_size50[54]->in[1] mux_2level_size50[54]->in[2] mux_2level_size50[54]->in[3] mux_2level_size50[54]->in[4] mux_2level_size50[54]->in[5] mux_2level_size50[54]->in[6] mux_2level_size50[54]->in[7] mux_2level_size50[54]->in[8] mux_2level_size50[54]->in[9] mux_2level_size50[54]->in[10] mux_2level_size50[54]->in[11] mux_2level_size50[54]->in[12] mux_2level_size50[54]->in[13] mux_2level_size50[54]->in[14] mux_2level_size50[54]->in[15] mux_2level_size50[54]->in[16] mux_2level_size50[54]->in[17] mux_2level_size50[54]->in[18] mux_2level_size50[54]->in[19] mux_2level_size50[54]->in[20] mux_2level_size50[54]->in[21] mux_2level_size50[54]->in[22] mux_2level_size50[54]->in[23] mux_2level_size50[54]->in[24] mux_2level_size50[54]->in[25] mux_2level_size50[54]->in[26] mux_2level_size50[54]->in[27] mux_2level_size50[54]->in[28] mux_2level_size50[54]->in[29] mux_2level_size50[54]->in[30] mux_2level_size50[54]->in[31] mux_2level_size50[54]->in[32] mux_2level_size50[54]->in[33] mux_2level_size50[54]->in[34] mux_2level_size50[54]->in[35] mux_2level_size50[54]->in[36] mux_2level_size50[54]->in[37] mux_2level_size50[54]->in[38] mux_2level_size50[54]->in[39] mux_2level_size50[54]->in[40] mux_2level_size50[54]->in[41] mux_2level_size50[54]->in[42] mux_2level_size50[54]->in[43] mux_2level_size50[54]->in[44] mux_2level_size50[54]->in[45] mux_2level_size50[54]->in[46] mux_2level_size50[54]->in[47] mux_2level_size50[54]->in[48] mux_2level_size50[54]->in[49] mux_2level_size50[54]->out sram[864]->out sram[864]->outb sram[865]->out sram[865]->outb sram[866]->outb sram[866]->out sram[867]->out sram[867]->outb sram[868]->out sram[868]->outb sram[869]->out sram[869]->outb sram[870]->out sram[870]->outb sram[871]->out sram[871]->outb sram[872]->out sram[872]->outb sram[873]->out sram[873]->outb sram[874]->out sram[874]->outb sram[875]->out sram[875]->outb sram[876]->out sram[876]->outb sram[877]->out sram[877]->outb sram[878]->outb sram[878]->out sram[879]->out sram[879]->outb gvdd_mux_2level_size50[54] 0 mux_2level_size50
***** SRAM bits for MUX[54], level=2, select_path_id=22. *****
*****0010000000000010*****
Xsram[864] sram->in sram[864]->out sram[864]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[864]->out) 0
.nodeset V(sram[864]->outb) vsp
Xsram[865] sram->in sram[865]->out sram[865]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[865]->out) 0
.nodeset V(sram[865]->outb) vsp
Xsram[866] sram->in sram[866]->out sram[866]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[866]->out) 0
.nodeset V(sram[866]->outb) vsp
Xsram[867] sram->in sram[867]->out sram[867]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[867]->out) 0
.nodeset V(sram[867]->outb) vsp
Xsram[868] sram->in sram[868]->out sram[868]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[868]->out) 0
.nodeset V(sram[868]->outb) vsp
Xsram[869] sram->in sram[869]->out sram[869]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[869]->out) 0
.nodeset V(sram[869]->outb) vsp
Xsram[870] sram->in sram[870]->out sram[870]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[870]->out) 0
.nodeset V(sram[870]->outb) vsp
Xsram[871] sram->in sram[871]->out sram[871]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[871]->out) 0
.nodeset V(sram[871]->outb) vsp
Xsram[872] sram->in sram[872]->out sram[872]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[872]->out) 0
.nodeset V(sram[872]->outb) vsp
Xsram[873] sram->in sram[873]->out sram[873]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[873]->out) 0
.nodeset V(sram[873]->outb) vsp
Xsram[874] sram->in sram[874]->out sram[874]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[874]->out) 0
.nodeset V(sram[874]->outb) vsp
Xsram[875] sram->in sram[875]->out sram[875]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[875]->out) 0
.nodeset V(sram[875]->outb) vsp
Xsram[876] sram->in sram[876]->out sram[876]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[876]->out) 0
.nodeset V(sram[876]->outb) vsp
Xsram[877] sram->in sram[877]->out sram[877]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[877]->out) 0
.nodeset V(sram[877]->outb) vsp
Xsram[878] sram->in sram[878]->out sram[878]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[878]->out) 0
.nodeset V(sram[878]->outb) vsp
Xsram[879] sram->in sram[879]->out sram[879]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[879]->out) 0
.nodeset V(sram[879]->outb) vsp
***** Signal mux_2level_size50[54]->in[0] density = 0, probability=0.*****
Vmux_2level_size50[54]->in[0] mux_2level_size50[54]->in[0] 0
+  0
***** Signal mux_2level_size50[54]->in[1] density = 0, probability=0.*****
Vmux_2level_size50[54]->in[1] mux_2level_size50[54]->in[1] 0
+  0
***** Signal mux_2level_size50[54]->in[2] density = 0, probability=0.*****
Vmux_2level_size50[54]->in[2] mux_2level_size50[54]->in[2] 0
+  0
***** Signal mux_2level_size50[54]->in[3] density = 0, probability=0.*****
Vmux_2level_size50[54]->in[3] mux_2level_size50[54]->in[3] 0
+  0
***** Signal mux_2level_size50[54]->in[4] density = 0, probability=0.*****
Vmux_2level_size50[54]->in[4] mux_2level_size50[54]->in[4] 0
+  0
***** Signal mux_2level_size50[54]->in[5] density = 0, probability=0.*****
Vmux_2level_size50[54]->in[5] mux_2level_size50[54]->in[5] 0
+  0
***** Signal mux_2level_size50[54]->in[6] density = 0, probability=0.*****
Vmux_2level_size50[54]->in[6] mux_2level_size50[54]->in[6] 0
+  0
***** Signal mux_2level_size50[54]->in[7] density = 0, probability=0.*****
Vmux_2level_size50[54]->in[7] mux_2level_size50[54]->in[7] 0
+  0
***** Signal mux_2level_size50[54]->in[8] density = 0, probability=0.*****
Vmux_2level_size50[54]->in[8] mux_2level_size50[54]->in[8] 0
+  0
***** Signal mux_2level_size50[54]->in[9] density = 0, probability=0.*****
Vmux_2level_size50[54]->in[9] mux_2level_size50[54]->in[9] 0
+  0
***** Signal mux_2level_size50[54]->in[10] density = 0, probability=0.*****
Vmux_2level_size50[54]->in[10] mux_2level_size50[54]->in[10] 0
+  0
***** Signal mux_2level_size50[54]->in[11] density = 0, probability=0.*****
Vmux_2level_size50[54]->in[11] mux_2level_size50[54]->in[11] 0
+  0
***** Signal mux_2level_size50[54]->in[12] density = 0, probability=0.*****
Vmux_2level_size50[54]->in[12] mux_2level_size50[54]->in[12] 0
+  0
***** Signal mux_2level_size50[54]->in[13] density = 0, probability=0.*****
Vmux_2level_size50[54]->in[13] mux_2level_size50[54]->in[13] 0
+  0
***** Signal mux_2level_size50[54]->in[14] density = 0, probability=0.*****
Vmux_2level_size50[54]->in[14] mux_2level_size50[54]->in[14] 0
+  0
***** Signal mux_2level_size50[54]->in[15] density = 0, probability=0.*****
Vmux_2level_size50[54]->in[15] mux_2level_size50[54]->in[15] 0
+  0
***** Signal mux_2level_size50[54]->in[16] density = 0, probability=0.*****
Vmux_2level_size50[54]->in[16] mux_2level_size50[54]->in[16] 0
+  0
***** Signal mux_2level_size50[54]->in[17] density = 0, probability=0.*****
Vmux_2level_size50[54]->in[17] mux_2level_size50[54]->in[17] 0
+  0
***** Signal mux_2level_size50[54]->in[18] density = 0, probability=0.*****
Vmux_2level_size50[54]->in[18] mux_2level_size50[54]->in[18] 0
+  0
***** Signal mux_2level_size50[54]->in[19] density = 0, probability=0.*****
Vmux_2level_size50[54]->in[19] mux_2level_size50[54]->in[19] 0
+  0
***** Signal mux_2level_size50[54]->in[20] density = 0, probability=0.*****
Vmux_2level_size50[54]->in[20] mux_2level_size50[54]->in[20] 0
+  0
***** Signal mux_2level_size50[54]->in[21] density = 0, probability=0.*****
Vmux_2level_size50[54]->in[21] mux_2level_size50[54]->in[21] 0
+  0
***** Signal mux_2level_size50[54]->in[22] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[54]->in[22] mux_2level_size50[54]->in[22] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[54]->in[23] density = 0, probability=0.*****
Vmux_2level_size50[54]->in[23] mux_2level_size50[54]->in[23] 0
+  0
***** Signal mux_2level_size50[54]->in[24] density = 0, probability=0.*****
Vmux_2level_size50[54]->in[24] mux_2level_size50[54]->in[24] 0
+  0
***** Signal mux_2level_size50[54]->in[25] density = 0, probability=0.*****
Vmux_2level_size50[54]->in[25] mux_2level_size50[54]->in[25] 0
+  0
***** Signal mux_2level_size50[54]->in[26] density = 0, probability=0.*****
Vmux_2level_size50[54]->in[26] mux_2level_size50[54]->in[26] 0
+  0
***** Signal mux_2level_size50[54]->in[27] density = 0, probability=0.*****
Vmux_2level_size50[54]->in[27] mux_2level_size50[54]->in[27] 0
+  0
***** Signal mux_2level_size50[54]->in[28] density = 0, probability=0.*****
Vmux_2level_size50[54]->in[28] mux_2level_size50[54]->in[28] 0
+  0
***** Signal mux_2level_size50[54]->in[29] density = 0, probability=0.*****
Vmux_2level_size50[54]->in[29] mux_2level_size50[54]->in[29] 0
+  0
***** Signal mux_2level_size50[54]->in[30] density = 0, probability=0.*****
Vmux_2level_size50[54]->in[30] mux_2level_size50[54]->in[30] 0
+  0
***** Signal mux_2level_size50[54]->in[31] density = 0, probability=0.*****
Vmux_2level_size50[54]->in[31] mux_2level_size50[54]->in[31] 0
+  0
***** Signal mux_2level_size50[54]->in[32] density = 0, probability=0.*****
Vmux_2level_size50[54]->in[32] mux_2level_size50[54]->in[32] 0
+  0
***** Signal mux_2level_size50[54]->in[33] density = 0, probability=0.*****
Vmux_2level_size50[54]->in[33] mux_2level_size50[54]->in[33] 0
+  0
***** Signal mux_2level_size50[54]->in[34] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[54]->in[34] mux_2level_size50[54]->in[34] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[54]->in[35] density = 0, probability=0.*****
Vmux_2level_size50[54]->in[35] mux_2level_size50[54]->in[35] 0
+  0
***** Signal mux_2level_size50[54]->in[36] density = 0, probability=0.*****
Vmux_2level_size50[54]->in[36] mux_2level_size50[54]->in[36] 0
+  0
***** Signal mux_2level_size50[54]->in[37] density = 0, probability=0.*****
Vmux_2level_size50[54]->in[37] mux_2level_size50[54]->in[37] 0
+  0
***** Signal mux_2level_size50[54]->in[38] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[54]->in[38] mux_2level_size50[54]->in[38] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[54]->in[39] density = 0, probability=0.*****
Vmux_2level_size50[54]->in[39] mux_2level_size50[54]->in[39] 0
+  0
***** Signal mux_2level_size50[54]->in[40] density = 0, probability=0.*****
Vmux_2level_size50[54]->in[40] mux_2level_size50[54]->in[40] 0
+  0
***** Signal mux_2level_size50[54]->in[41] density = 0, probability=0.*****
Vmux_2level_size50[54]->in[41] mux_2level_size50[54]->in[41] 0
+  0
***** Signal mux_2level_size50[54]->in[42] density = 0, probability=0.*****
Vmux_2level_size50[54]->in[42] mux_2level_size50[54]->in[42] 0
+  0
***** Signal mux_2level_size50[54]->in[43] density = 0, probability=0.*****
Vmux_2level_size50[54]->in[43] mux_2level_size50[54]->in[43] 0
+  0
***** Signal mux_2level_size50[54]->in[44] density = 0, probability=0.*****
Vmux_2level_size50[54]->in[44] mux_2level_size50[54]->in[44] 0
+  0
***** Signal mux_2level_size50[54]->in[45] density = 0, probability=0.*****
Vmux_2level_size50[54]->in[45] mux_2level_size50[54]->in[45] 0
+  0
***** Signal mux_2level_size50[54]->in[46] density = 0, probability=0.*****
Vmux_2level_size50[54]->in[46] mux_2level_size50[54]->in[46] 0
+  0
***** Signal mux_2level_size50[54]->in[47] density = 0, probability=0.*****
Vmux_2level_size50[54]->in[47] mux_2level_size50[54]->in[47] 0
+  0
***** Signal mux_2level_size50[54]->in[48] density = 0, probability=0.*****
Vmux_2level_size50[54]->in[48] mux_2level_size50[54]->in[48] 0
+  0
***** Signal mux_2level_size50[54]->in[49] density = 0.2026, probability=0.4982.*****
Vmux_2level_size50[54]->in[49] mux_2level_size50[54]->in[49] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.4982*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
Vgvdd_mux_2level_size50[54] gvdd_mux_2level_size50[54] 0 vsp
***** Measurements *****
***** Rise delay *****
.meas tran delay_rise_grid[1][1]_clb[0]_mode[clb]_fle[9]_mode[n1_lut6]_in[0]_crossbar trig v(mux_2level_size50[54]->in[22]) val='input_thres_pct_rise*vsp' rise=1 td='clock_period'
+          targ v(mux_2level_size50[54]->out) val='output_thres_pct_rise*vsp' rise=1 td='clock_period'
***** Fall delay *****
.meas tran delay_fall_grid[1][1]_clb[0]_mode[clb]_fle[9]_mode[n1_lut6]_in[0]_crossbar trig v(mux_2level_size50[54]->in[22]) val='input_thres_pct_fall*vsp' fall=1 td='clock_period'
+          targ v(mux_2level_size50[54]->out) val='output_thres_pct_fall*vsp' fall=1 td='clock_period'
***** Rise timing period *****
.meas start_rise_grid[1][1]_clb[0]_mode[clb]_fle[9]_mode[n1_lut6]_in[0]_crossbar when v(mux_2level_size50[54]->in[22])='slew_lower_thres_pct_rise*vsp' rise=1 td='clock_period'
.meas tran switch_rise_grid[1][1]_clb[0]_mode[clb]_fle[9]_mode[n1_lut6]_in[0]_crossbar trig v(mux_2level_size50[54]->in[22]) val='slew_lower_thres_pct_rise*vsp' rise=1 td='clock_period'
+          targ v(mux_2level_size50[54]->out) val='slew_upper_thres_pct_rise*vsp' rise=1 td='clock_period'
***** Fall timing period *****
.meas start_fall_grid[1][1]_clb[0]_mode[clb]_fle[9]_mode[n1_lut6]_in[0]_crossbar when v(mux_2level_size50[54]->in[22])='slew_lower_thres_pct_fall*vsp' fall=1 td='clock_period'
.meas tran switch_fall_grid[1][1]_clb[0]_mode[clb]_fle[9]_mode[n1_lut6]_in[0]_crossbar trig v(mux_2level_size50[54]->in[22]) val='slew_lower_thres_pct_fall*vsp' fall=1 td='clock_period'
+          targ v(mux_2level_size50[54]->out) val='slew_upper_thres_pct_fall*vsp' fall=1 td='clock_period'
***** Leakage Power Measurement *****
.meas tran mux_2level_size50[54]_leakage_power avg p(Vgvdd_mux_2level_size50[54]) from=0 to='clock_period'
.meas tran leakage_grid[1][1]_clb[0]_mode[clb]_fle[9]_mode[n1_lut6]_in[0]_crossbar param='mux_2level_size50[54]_leakage_power'
***** Dynamic Power Measurement *****
.meas tran mux_2level_size50[54]_dynamic_power avg p(Vgvdd_mux_2level_size50[54]) from='clock_period' to='6*clock_period'
.meas tran mux_2level_size50[54]_energy_per_cycle param='mux_2level_size50[54]_dynamic_power*clock_period'
.meas tran dynamic_power_grid[1][1]_clb[0]_mode[clb]_fle[9]_mode[n1_lut6]_in[0]_crossbar  param='mux_2level_size50[54]_dynamic_power'
.meas tran energy_per_cycle_grid[1][1]_clb[0]_mode[clb]_fle[9]_mode[n1_lut6]_in[0]_crossbar  param='dynamic_power_grid[1][1]_clb[0]_mode[clb]_fle[9]_mode[n1_lut6]_in[0]_crossbar*clock_period'
.meas tran dynamic_rise_grid[1][1]_clb[0]_mode[clb]_fle[9]_mode[n1_lut6]_in[0]_crossbar avg p(Vgvdd_mux_2level_size50[54]) from='start_rise_grid[1][1]_clb[0]_mode[clb]_fle[9]_mode[n1_lut6]_in[0]_crossbar' to='start_rise_grid[1][1]_clb[0]_mode[clb]_fle[9]_mode[n1_lut6]_in[0]_crossbar+switch_rise_grid[1][1]_clb[0]_mode[clb]_fle[9]_mode[n1_lut6]_in[0]_crossbar'
.meas tran dynamic_fall_grid[1][1]_clb[0]_mode[clb]_fle[9]_mode[n1_lut6]_in[0]_crossbar avg p(Vgvdd_mux_2level_size50[54]) from='start_fall_grid[1][1]_clb[0]_mode[clb]_fle[9]_mode[n1_lut6]_in[0]_crossbar' to='start_fall_grid[1][1]_clb[0]_mode[clb]_fle[9]_mode[n1_lut6]_in[0]_crossbar+switch_fall_grid[1][1]_clb[0]_mode[clb]_fle[9]_mode[n1_lut6]_in[0]_crossbar'
.meas tran sum_leakage_power_mux[0to54]
+          param='sum_leakage_power_mux[0to53]+leakage_grid[1][1]_clb[0]_mode[clb]_fle[9]_mode[n1_lut6]_in[0]_crossbar'
.meas tran sum_energy_per_cycle_mux[0to54]
+          param='sum_energy_per_cycle_mux[0to53]+energy_per_cycle_grid[1][1]_clb[0]_mode[clb]_fle[9]_mode[n1_lut6]_in[0]_crossbar'
Xload_inv[54]_no0 mux_2level_size50[54]->out mux_2level_size50[54]->out_out[0] gvdd_load 0 inv size=5
.meas tran sum_leakage_power_pb_mux[0to54]
+          param='sum_leakage_power_pb_mux[0to53]+leakage_grid[1][1]_clb[0]_mode[clb]_fle[9]_mode[n1_lut6]_in[0]_crossbar'
.meas tran sum_energy_per_cycle_pb_mux[0to54]
+          param='sum_energy_per_cycle_pb_mux[0to53]+energy_per_cycle_grid[1][1]_clb[0]_mode[clb]_fle[9]_mode[n1_lut6]_in[0]_crossbar'
Xmux_2level_size50[55] mux_2level_size50[55]->in[0] mux_2level_size50[55]->in[1] mux_2level_size50[55]->in[2] mux_2level_size50[55]->in[3] mux_2level_size50[55]->in[4] mux_2level_size50[55]->in[5] mux_2level_size50[55]->in[6] mux_2level_size50[55]->in[7] mux_2level_size50[55]->in[8] mux_2level_size50[55]->in[9] mux_2level_size50[55]->in[10] mux_2level_size50[55]->in[11] mux_2level_size50[55]->in[12] mux_2level_size50[55]->in[13] mux_2level_size50[55]->in[14] mux_2level_size50[55]->in[15] mux_2level_size50[55]->in[16] mux_2level_size50[55]->in[17] mux_2level_size50[55]->in[18] mux_2level_size50[55]->in[19] mux_2level_size50[55]->in[20] mux_2level_size50[55]->in[21] mux_2level_size50[55]->in[22] mux_2level_size50[55]->in[23] mux_2level_size50[55]->in[24] mux_2level_size50[55]->in[25] mux_2level_size50[55]->in[26] mux_2level_size50[55]->in[27] mux_2level_size50[55]->in[28] mux_2level_size50[55]->in[29] mux_2level_size50[55]->in[30] mux_2level_size50[55]->in[31] mux_2level_size50[55]->in[32] mux_2level_size50[55]->in[33] mux_2level_size50[55]->in[34] mux_2level_size50[55]->in[35] mux_2level_size50[55]->in[36] mux_2level_size50[55]->in[37] mux_2level_size50[55]->in[38] mux_2level_size50[55]->in[39] mux_2level_size50[55]->in[40] mux_2level_size50[55]->in[41] mux_2level_size50[55]->in[42] mux_2level_size50[55]->in[43] mux_2level_size50[55]->in[44] mux_2level_size50[55]->in[45] mux_2level_size50[55]->in[46] mux_2level_size50[55]->in[47] mux_2level_size50[55]->in[48] mux_2level_size50[55]->in[49] mux_2level_size50[55]->out sram[880]->outb sram[880]->out sram[881]->out sram[881]->outb sram[882]->out sram[882]->outb sram[883]->out sram[883]->outb sram[884]->out sram[884]->outb sram[885]->out sram[885]->outb sram[886]->out sram[886]->outb sram[887]->out sram[887]->outb sram[888]->outb sram[888]->out sram[889]->out sram[889]->outb sram[890]->out sram[890]->outb sram[891]->out sram[891]->outb sram[892]->out sram[892]->outb sram[893]->out sram[893]->outb sram[894]->out sram[894]->outb sram[895]->out sram[895]->outb gvdd_mux_2level_size50[55] 0 mux_2level_size50
***** SRAM bits for MUX[55], level=2, select_path_id=0. *****
*****1000000010000000*****
Xsram[880] sram->in sram[880]->out sram[880]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[880]->out) 0
.nodeset V(sram[880]->outb) vsp
Xsram[881] sram->in sram[881]->out sram[881]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[881]->out) 0
.nodeset V(sram[881]->outb) vsp
Xsram[882] sram->in sram[882]->out sram[882]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[882]->out) 0
.nodeset V(sram[882]->outb) vsp
Xsram[883] sram->in sram[883]->out sram[883]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[883]->out) 0
.nodeset V(sram[883]->outb) vsp
Xsram[884] sram->in sram[884]->out sram[884]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[884]->out) 0
.nodeset V(sram[884]->outb) vsp
Xsram[885] sram->in sram[885]->out sram[885]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[885]->out) 0
.nodeset V(sram[885]->outb) vsp
Xsram[886] sram->in sram[886]->out sram[886]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[886]->out) 0
.nodeset V(sram[886]->outb) vsp
Xsram[887] sram->in sram[887]->out sram[887]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[887]->out) 0
.nodeset V(sram[887]->outb) vsp
Xsram[888] sram->in sram[888]->out sram[888]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[888]->out) 0
.nodeset V(sram[888]->outb) vsp
Xsram[889] sram->in sram[889]->out sram[889]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[889]->out) 0
.nodeset V(sram[889]->outb) vsp
Xsram[890] sram->in sram[890]->out sram[890]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[890]->out) 0
.nodeset V(sram[890]->outb) vsp
Xsram[891] sram->in sram[891]->out sram[891]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[891]->out) 0
.nodeset V(sram[891]->outb) vsp
Xsram[892] sram->in sram[892]->out sram[892]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[892]->out) 0
.nodeset V(sram[892]->outb) vsp
Xsram[893] sram->in sram[893]->out sram[893]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[893]->out) 0
.nodeset V(sram[893]->outb) vsp
Xsram[894] sram->in sram[894]->out sram[894]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[894]->out) 0
.nodeset V(sram[894]->outb) vsp
Xsram[895] sram->in sram[895]->out sram[895]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[895]->out) 0
.nodeset V(sram[895]->outb) vsp
***** Signal mux_2level_size50[55]->in[0] density = 0, probability=0.*****
Vmux_2level_size50[55]->in[0] mux_2level_size50[55]->in[0] 0
+  0
***** Signal mux_2level_size50[55]->in[1] density = 0, probability=0.*****
Vmux_2level_size50[55]->in[1] mux_2level_size50[55]->in[1] 0
+  0
***** Signal mux_2level_size50[55]->in[2] density = 0, probability=0.*****
Vmux_2level_size50[55]->in[2] mux_2level_size50[55]->in[2] 0
+  0
***** Signal mux_2level_size50[55]->in[3] density = 0, probability=0.*****
Vmux_2level_size50[55]->in[3] mux_2level_size50[55]->in[3] 0
+  0
***** Signal mux_2level_size50[55]->in[4] density = 0, probability=0.*****
Vmux_2level_size50[55]->in[4] mux_2level_size50[55]->in[4] 0
+  0
***** Signal mux_2level_size50[55]->in[5] density = 0, probability=0.*****
Vmux_2level_size50[55]->in[5] mux_2level_size50[55]->in[5] 0
+  0
***** Signal mux_2level_size50[55]->in[6] density = 0, probability=0.*****
Vmux_2level_size50[55]->in[6] mux_2level_size50[55]->in[6] 0
+  0
***** Signal mux_2level_size50[55]->in[7] density = 0, probability=0.*****
Vmux_2level_size50[55]->in[7] mux_2level_size50[55]->in[7] 0
+  0
***** Signal mux_2level_size50[55]->in[8] density = 0, probability=0.*****
Vmux_2level_size50[55]->in[8] mux_2level_size50[55]->in[8] 0
+  0
***** Signal mux_2level_size50[55]->in[9] density = 0, probability=0.*****
Vmux_2level_size50[55]->in[9] mux_2level_size50[55]->in[9] 0
+  0
***** Signal mux_2level_size50[55]->in[10] density = 0, probability=0.*****
Vmux_2level_size50[55]->in[10] mux_2level_size50[55]->in[10] 0
+  0
***** Signal mux_2level_size50[55]->in[11] density = 0, probability=0.*****
Vmux_2level_size50[55]->in[11] mux_2level_size50[55]->in[11] 0
+  0
***** Signal mux_2level_size50[55]->in[12] density = 0, probability=0.*****
Vmux_2level_size50[55]->in[12] mux_2level_size50[55]->in[12] 0
+  0
***** Signal mux_2level_size50[55]->in[13] density = 0, probability=0.*****
Vmux_2level_size50[55]->in[13] mux_2level_size50[55]->in[13] 0
+  0
***** Signal mux_2level_size50[55]->in[14] density = 0, probability=0.*****
Vmux_2level_size50[55]->in[14] mux_2level_size50[55]->in[14] 0
+  0
***** Signal mux_2level_size50[55]->in[15] density = 0, probability=0.*****
Vmux_2level_size50[55]->in[15] mux_2level_size50[55]->in[15] 0
+  0
***** Signal mux_2level_size50[55]->in[16] density = 0, probability=0.*****
Vmux_2level_size50[55]->in[16] mux_2level_size50[55]->in[16] 0
+  0
***** Signal mux_2level_size50[55]->in[17] density = 0, probability=0.*****
Vmux_2level_size50[55]->in[17] mux_2level_size50[55]->in[17] 0
+  0
***** Signal mux_2level_size50[55]->in[18] density = 0, probability=0.*****
Vmux_2level_size50[55]->in[18] mux_2level_size50[55]->in[18] 0
+  0
***** Signal mux_2level_size50[55]->in[19] density = 0, probability=0.*****
Vmux_2level_size50[55]->in[19] mux_2level_size50[55]->in[19] 0
+  0
***** Signal mux_2level_size50[55]->in[20] density = 0, probability=0.*****
Vmux_2level_size50[55]->in[20] mux_2level_size50[55]->in[20] 0
+  0
***** Signal mux_2level_size50[55]->in[21] density = 0, probability=0.*****
Vmux_2level_size50[55]->in[21] mux_2level_size50[55]->in[21] 0
+  0
***** Signal mux_2level_size50[55]->in[22] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[55]->in[22] mux_2level_size50[55]->in[22] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[55]->in[23] density = 0, probability=0.*****
Vmux_2level_size50[55]->in[23] mux_2level_size50[55]->in[23] 0
+  0
***** Signal mux_2level_size50[55]->in[24] density = 0, probability=0.*****
Vmux_2level_size50[55]->in[24] mux_2level_size50[55]->in[24] 0
+  0
***** Signal mux_2level_size50[55]->in[25] density = 0, probability=0.*****
Vmux_2level_size50[55]->in[25] mux_2level_size50[55]->in[25] 0
+  0
***** Signal mux_2level_size50[55]->in[26] density = 0, probability=0.*****
Vmux_2level_size50[55]->in[26] mux_2level_size50[55]->in[26] 0
+  0
***** Signal mux_2level_size50[55]->in[27] density = 0, probability=0.*****
Vmux_2level_size50[55]->in[27] mux_2level_size50[55]->in[27] 0
+  0
***** Signal mux_2level_size50[55]->in[28] density = 0, probability=0.*****
Vmux_2level_size50[55]->in[28] mux_2level_size50[55]->in[28] 0
+  0
***** Signal mux_2level_size50[55]->in[29] density = 0, probability=0.*****
Vmux_2level_size50[55]->in[29] mux_2level_size50[55]->in[29] 0
+  0
***** Signal mux_2level_size50[55]->in[30] density = 0, probability=0.*****
Vmux_2level_size50[55]->in[30] mux_2level_size50[55]->in[30] 0
+  0
***** Signal mux_2level_size50[55]->in[31] density = 0, probability=0.*****
Vmux_2level_size50[55]->in[31] mux_2level_size50[55]->in[31] 0
+  0
***** Signal mux_2level_size50[55]->in[32] density = 0, probability=0.*****
Vmux_2level_size50[55]->in[32] mux_2level_size50[55]->in[32] 0
+  0
***** Signal mux_2level_size50[55]->in[33] density = 0, probability=0.*****
Vmux_2level_size50[55]->in[33] mux_2level_size50[55]->in[33] 0
+  0
***** Signal mux_2level_size50[55]->in[34] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[55]->in[34] mux_2level_size50[55]->in[34] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[55]->in[35] density = 0, probability=0.*****
Vmux_2level_size50[55]->in[35] mux_2level_size50[55]->in[35] 0
+  0
***** Signal mux_2level_size50[55]->in[36] density = 0, probability=0.*****
Vmux_2level_size50[55]->in[36] mux_2level_size50[55]->in[36] 0
+  0
***** Signal mux_2level_size50[55]->in[37] density = 0, probability=0.*****
Vmux_2level_size50[55]->in[37] mux_2level_size50[55]->in[37] 0
+  0
***** Signal mux_2level_size50[55]->in[38] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[55]->in[38] mux_2level_size50[55]->in[38] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[55]->in[39] density = 0, probability=0.*****
Vmux_2level_size50[55]->in[39] mux_2level_size50[55]->in[39] 0
+  0
***** Signal mux_2level_size50[55]->in[40] density = 0, probability=0.*****
Vmux_2level_size50[55]->in[40] mux_2level_size50[55]->in[40] 0
+  0
***** Signal mux_2level_size50[55]->in[41] density = 0, probability=0.*****
Vmux_2level_size50[55]->in[41] mux_2level_size50[55]->in[41] 0
+  0
***** Signal mux_2level_size50[55]->in[42] density = 0, probability=0.*****
Vmux_2level_size50[55]->in[42] mux_2level_size50[55]->in[42] 0
+  0
***** Signal mux_2level_size50[55]->in[43] density = 0, probability=0.*****
Vmux_2level_size50[55]->in[43] mux_2level_size50[55]->in[43] 0
+  0
***** Signal mux_2level_size50[55]->in[44] density = 0, probability=0.*****
Vmux_2level_size50[55]->in[44] mux_2level_size50[55]->in[44] 0
+  0
***** Signal mux_2level_size50[55]->in[45] density = 0, probability=0.*****
Vmux_2level_size50[55]->in[45] mux_2level_size50[55]->in[45] 0
+  0
***** Signal mux_2level_size50[55]->in[46] density = 0, probability=0.*****
Vmux_2level_size50[55]->in[46] mux_2level_size50[55]->in[46] 0
+  0
***** Signal mux_2level_size50[55]->in[47] density = 0, probability=0.*****
Vmux_2level_size50[55]->in[47] mux_2level_size50[55]->in[47] 0
+  0
***** Signal mux_2level_size50[55]->in[48] density = 0, probability=0.*****
Vmux_2level_size50[55]->in[48] mux_2level_size50[55]->in[48] 0
+  0
***** Signal mux_2level_size50[55]->in[49] density = 0.2026, probability=0.4982.*****
Vmux_2level_size50[55]->in[49] mux_2level_size50[55]->in[49] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.4982*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
Vgvdd_mux_2level_size50[55] gvdd_mux_2level_size50[55] 0 vsp
***** Measurements *****
***** Rise delay *****
.meas tran delay_rise_grid[1][1]_clb[0]_mode[clb]_fle[9]_mode[n1_lut6]_in[1]_crossbar trig v(mux_2level_size50[55]->in[0]) val='input_thres_pct_rise*vsp' rise=1 td='clock_period'
+          targ v(mux_2level_size50[55]->out) val='output_thres_pct_rise*vsp' rise=1 td='clock_period'
***** Fall delay *****
.meas tran delay_fall_grid[1][1]_clb[0]_mode[clb]_fle[9]_mode[n1_lut6]_in[1]_crossbar trig v(mux_2level_size50[55]->in[0]) val='input_thres_pct_fall*vsp' fall=1 td='clock_period'
+          targ v(mux_2level_size50[55]->out) val='output_thres_pct_fall*vsp' fall=1 td='clock_period'
***** Rise timing period *****
.meas start_rise_grid[1][1]_clb[0]_mode[clb]_fle[9]_mode[n1_lut6]_in[1]_crossbar when v(mux_2level_size50[55]->in[0])='slew_lower_thres_pct_rise*vsp' rise=1 td='clock_period'
.meas tran switch_rise_grid[1][1]_clb[0]_mode[clb]_fle[9]_mode[n1_lut6]_in[1]_crossbar trig v(mux_2level_size50[55]->in[0]) val='slew_lower_thres_pct_rise*vsp' rise=1 td='clock_period'
+          targ v(mux_2level_size50[55]->out) val='slew_upper_thres_pct_rise*vsp' rise=1 td='clock_period'
***** Fall timing period *****
.meas start_fall_grid[1][1]_clb[0]_mode[clb]_fle[9]_mode[n1_lut6]_in[1]_crossbar when v(mux_2level_size50[55]->in[0])='slew_lower_thres_pct_fall*vsp' fall=1 td='clock_period'
.meas tran switch_fall_grid[1][1]_clb[0]_mode[clb]_fle[9]_mode[n1_lut6]_in[1]_crossbar trig v(mux_2level_size50[55]->in[0]) val='slew_lower_thres_pct_fall*vsp' fall=1 td='clock_period'
+          targ v(mux_2level_size50[55]->out) val='slew_upper_thres_pct_fall*vsp' fall=1 td='clock_period'
***** Leakage Power Measurement *****
.meas tran mux_2level_size50[55]_leakage_power avg p(Vgvdd_mux_2level_size50[55]) from=0 to='clock_period'
.meas tran leakage_grid[1][1]_clb[0]_mode[clb]_fle[9]_mode[n1_lut6]_in[1]_crossbar param='mux_2level_size50[55]_leakage_power'
***** Dynamic Power Measurement *****
.meas tran mux_2level_size50[55]_dynamic_power avg p(Vgvdd_mux_2level_size50[55]) from='clock_period' to='6*clock_period'
.meas tran mux_2level_size50[55]_energy_per_cycle param='mux_2level_size50[55]_dynamic_power*clock_period'
.meas tran dynamic_power_grid[1][1]_clb[0]_mode[clb]_fle[9]_mode[n1_lut6]_in[1]_crossbar  param='mux_2level_size50[55]_dynamic_power'
.meas tran energy_per_cycle_grid[1][1]_clb[0]_mode[clb]_fle[9]_mode[n1_lut6]_in[1]_crossbar  param='dynamic_power_grid[1][1]_clb[0]_mode[clb]_fle[9]_mode[n1_lut6]_in[1]_crossbar*clock_period'
.meas tran dynamic_rise_grid[1][1]_clb[0]_mode[clb]_fle[9]_mode[n1_lut6]_in[1]_crossbar avg p(Vgvdd_mux_2level_size50[55]) from='start_rise_grid[1][1]_clb[0]_mode[clb]_fle[9]_mode[n1_lut6]_in[1]_crossbar' to='start_rise_grid[1][1]_clb[0]_mode[clb]_fle[9]_mode[n1_lut6]_in[1]_crossbar+switch_rise_grid[1][1]_clb[0]_mode[clb]_fle[9]_mode[n1_lut6]_in[1]_crossbar'
.meas tran dynamic_fall_grid[1][1]_clb[0]_mode[clb]_fle[9]_mode[n1_lut6]_in[1]_crossbar avg p(Vgvdd_mux_2level_size50[55]) from='start_fall_grid[1][1]_clb[0]_mode[clb]_fle[9]_mode[n1_lut6]_in[1]_crossbar' to='start_fall_grid[1][1]_clb[0]_mode[clb]_fle[9]_mode[n1_lut6]_in[1]_crossbar+switch_fall_grid[1][1]_clb[0]_mode[clb]_fle[9]_mode[n1_lut6]_in[1]_crossbar'
.meas tran sum_leakage_power_mux[0to55]
+          param='sum_leakage_power_mux[0to54]+leakage_grid[1][1]_clb[0]_mode[clb]_fle[9]_mode[n1_lut6]_in[1]_crossbar'
.meas tran sum_energy_per_cycle_mux[0to55]
+          param='sum_energy_per_cycle_mux[0to54]+energy_per_cycle_grid[1][1]_clb[0]_mode[clb]_fle[9]_mode[n1_lut6]_in[1]_crossbar'
Xload_inv[55]_no0 mux_2level_size50[55]->out mux_2level_size50[55]->out_out[0] gvdd_load 0 inv size=5
.meas tran sum_leakage_power_pb_mux[0to55]
+          param='sum_leakage_power_pb_mux[0to54]+leakage_grid[1][1]_clb[0]_mode[clb]_fle[9]_mode[n1_lut6]_in[1]_crossbar'
.meas tran sum_energy_per_cycle_pb_mux[0to55]
+          param='sum_energy_per_cycle_pb_mux[0to54]+energy_per_cycle_grid[1][1]_clb[0]_mode[clb]_fle[9]_mode[n1_lut6]_in[1]_crossbar'
Xmux_2level_size50[56] mux_2level_size50[56]->in[0] mux_2level_size50[56]->in[1] mux_2level_size50[56]->in[2] mux_2level_size50[56]->in[3] mux_2level_size50[56]->in[4] mux_2level_size50[56]->in[5] mux_2level_size50[56]->in[6] mux_2level_size50[56]->in[7] mux_2level_size50[56]->in[8] mux_2level_size50[56]->in[9] mux_2level_size50[56]->in[10] mux_2level_size50[56]->in[11] mux_2level_size50[56]->in[12] mux_2level_size50[56]->in[13] mux_2level_size50[56]->in[14] mux_2level_size50[56]->in[15] mux_2level_size50[56]->in[16] mux_2level_size50[56]->in[17] mux_2level_size50[56]->in[18] mux_2level_size50[56]->in[19] mux_2level_size50[56]->in[20] mux_2level_size50[56]->in[21] mux_2level_size50[56]->in[22] mux_2level_size50[56]->in[23] mux_2level_size50[56]->in[24] mux_2level_size50[56]->in[25] mux_2level_size50[56]->in[26] mux_2level_size50[56]->in[27] mux_2level_size50[56]->in[28] mux_2level_size50[56]->in[29] mux_2level_size50[56]->in[30] mux_2level_size50[56]->in[31] mux_2level_size50[56]->in[32] mux_2level_size50[56]->in[33] mux_2level_size50[56]->in[34] mux_2level_size50[56]->in[35] mux_2level_size50[56]->in[36] mux_2level_size50[56]->in[37] mux_2level_size50[56]->in[38] mux_2level_size50[56]->in[39] mux_2level_size50[56]->in[40] mux_2level_size50[56]->in[41] mux_2level_size50[56]->in[42] mux_2level_size50[56]->in[43] mux_2level_size50[56]->in[44] mux_2level_size50[56]->in[45] mux_2level_size50[56]->in[46] mux_2level_size50[56]->in[47] mux_2level_size50[56]->in[48] mux_2level_size50[56]->in[49] mux_2level_size50[56]->out sram[896]->outb sram[896]->out sram[897]->out sram[897]->outb sram[898]->out sram[898]->outb sram[899]->out sram[899]->outb sram[900]->out sram[900]->outb sram[901]->out sram[901]->outb sram[902]->out sram[902]->outb sram[903]->out sram[903]->outb sram[904]->outb sram[904]->out sram[905]->out sram[905]->outb sram[906]->out sram[906]->outb sram[907]->out sram[907]->outb sram[908]->out sram[908]->outb sram[909]->out sram[909]->outb sram[910]->out sram[910]->outb sram[911]->out sram[911]->outb gvdd_mux_2level_size50[56] 0 mux_2level_size50
***** SRAM bits for MUX[56], level=2, select_path_id=0. *****
*****1000000010000000*****
Xsram[896] sram->in sram[896]->out sram[896]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[896]->out) 0
.nodeset V(sram[896]->outb) vsp
Xsram[897] sram->in sram[897]->out sram[897]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[897]->out) 0
.nodeset V(sram[897]->outb) vsp
Xsram[898] sram->in sram[898]->out sram[898]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[898]->out) 0
.nodeset V(sram[898]->outb) vsp
Xsram[899] sram->in sram[899]->out sram[899]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[899]->out) 0
.nodeset V(sram[899]->outb) vsp
Xsram[900] sram->in sram[900]->out sram[900]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[900]->out) 0
.nodeset V(sram[900]->outb) vsp
Xsram[901] sram->in sram[901]->out sram[901]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[901]->out) 0
.nodeset V(sram[901]->outb) vsp
Xsram[902] sram->in sram[902]->out sram[902]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[902]->out) 0
.nodeset V(sram[902]->outb) vsp
Xsram[903] sram->in sram[903]->out sram[903]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[903]->out) 0
.nodeset V(sram[903]->outb) vsp
Xsram[904] sram->in sram[904]->out sram[904]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[904]->out) 0
.nodeset V(sram[904]->outb) vsp
Xsram[905] sram->in sram[905]->out sram[905]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[905]->out) 0
.nodeset V(sram[905]->outb) vsp
Xsram[906] sram->in sram[906]->out sram[906]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[906]->out) 0
.nodeset V(sram[906]->outb) vsp
Xsram[907] sram->in sram[907]->out sram[907]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[907]->out) 0
.nodeset V(sram[907]->outb) vsp
Xsram[908] sram->in sram[908]->out sram[908]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[908]->out) 0
.nodeset V(sram[908]->outb) vsp
Xsram[909] sram->in sram[909]->out sram[909]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[909]->out) 0
.nodeset V(sram[909]->outb) vsp
Xsram[910] sram->in sram[910]->out sram[910]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[910]->out) 0
.nodeset V(sram[910]->outb) vsp
Xsram[911] sram->in sram[911]->out sram[911]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[911]->out) 0
.nodeset V(sram[911]->outb) vsp
***** Signal mux_2level_size50[56]->in[0] density = 0, probability=0.*****
Vmux_2level_size50[56]->in[0] mux_2level_size50[56]->in[0] 0
+  0
***** Signal mux_2level_size50[56]->in[1] density = 0, probability=0.*****
Vmux_2level_size50[56]->in[1] mux_2level_size50[56]->in[1] 0
+  0
***** Signal mux_2level_size50[56]->in[2] density = 0, probability=0.*****
Vmux_2level_size50[56]->in[2] mux_2level_size50[56]->in[2] 0
+  0
***** Signal mux_2level_size50[56]->in[3] density = 0, probability=0.*****
Vmux_2level_size50[56]->in[3] mux_2level_size50[56]->in[3] 0
+  0
***** Signal mux_2level_size50[56]->in[4] density = 0, probability=0.*****
Vmux_2level_size50[56]->in[4] mux_2level_size50[56]->in[4] 0
+  0
***** Signal mux_2level_size50[56]->in[5] density = 0, probability=0.*****
Vmux_2level_size50[56]->in[5] mux_2level_size50[56]->in[5] 0
+  0
***** Signal mux_2level_size50[56]->in[6] density = 0, probability=0.*****
Vmux_2level_size50[56]->in[6] mux_2level_size50[56]->in[6] 0
+  0
***** Signal mux_2level_size50[56]->in[7] density = 0, probability=0.*****
Vmux_2level_size50[56]->in[7] mux_2level_size50[56]->in[7] 0
+  0
***** Signal mux_2level_size50[56]->in[8] density = 0, probability=0.*****
Vmux_2level_size50[56]->in[8] mux_2level_size50[56]->in[8] 0
+  0
***** Signal mux_2level_size50[56]->in[9] density = 0, probability=0.*****
Vmux_2level_size50[56]->in[9] mux_2level_size50[56]->in[9] 0
+  0
***** Signal mux_2level_size50[56]->in[10] density = 0, probability=0.*****
Vmux_2level_size50[56]->in[10] mux_2level_size50[56]->in[10] 0
+  0
***** Signal mux_2level_size50[56]->in[11] density = 0, probability=0.*****
Vmux_2level_size50[56]->in[11] mux_2level_size50[56]->in[11] 0
+  0
***** Signal mux_2level_size50[56]->in[12] density = 0, probability=0.*****
Vmux_2level_size50[56]->in[12] mux_2level_size50[56]->in[12] 0
+  0
***** Signal mux_2level_size50[56]->in[13] density = 0, probability=0.*****
Vmux_2level_size50[56]->in[13] mux_2level_size50[56]->in[13] 0
+  0
***** Signal mux_2level_size50[56]->in[14] density = 0, probability=0.*****
Vmux_2level_size50[56]->in[14] mux_2level_size50[56]->in[14] 0
+  0
***** Signal mux_2level_size50[56]->in[15] density = 0, probability=0.*****
Vmux_2level_size50[56]->in[15] mux_2level_size50[56]->in[15] 0
+  0
***** Signal mux_2level_size50[56]->in[16] density = 0, probability=0.*****
Vmux_2level_size50[56]->in[16] mux_2level_size50[56]->in[16] 0
+  0
***** Signal mux_2level_size50[56]->in[17] density = 0, probability=0.*****
Vmux_2level_size50[56]->in[17] mux_2level_size50[56]->in[17] 0
+  0
***** Signal mux_2level_size50[56]->in[18] density = 0, probability=0.*****
Vmux_2level_size50[56]->in[18] mux_2level_size50[56]->in[18] 0
+  0
***** Signal mux_2level_size50[56]->in[19] density = 0, probability=0.*****
Vmux_2level_size50[56]->in[19] mux_2level_size50[56]->in[19] 0
+  0
***** Signal mux_2level_size50[56]->in[20] density = 0, probability=0.*****
Vmux_2level_size50[56]->in[20] mux_2level_size50[56]->in[20] 0
+  0
***** Signal mux_2level_size50[56]->in[21] density = 0, probability=0.*****
Vmux_2level_size50[56]->in[21] mux_2level_size50[56]->in[21] 0
+  0
***** Signal mux_2level_size50[56]->in[22] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[56]->in[22] mux_2level_size50[56]->in[22] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[56]->in[23] density = 0, probability=0.*****
Vmux_2level_size50[56]->in[23] mux_2level_size50[56]->in[23] 0
+  0
***** Signal mux_2level_size50[56]->in[24] density = 0, probability=0.*****
Vmux_2level_size50[56]->in[24] mux_2level_size50[56]->in[24] 0
+  0
***** Signal mux_2level_size50[56]->in[25] density = 0, probability=0.*****
Vmux_2level_size50[56]->in[25] mux_2level_size50[56]->in[25] 0
+  0
***** Signal mux_2level_size50[56]->in[26] density = 0, probability=0.*****
Vmux_2level_size50[56]->in[26] mux_2level_size50[56]->in[26] 0
+  0
***** Signal mux_2level_size50[56]->in[27] density = 0, probability=0.*****
Vmux_2level_size50[56]->in[27] mux_2level_size50[56]->in[27] 0
+  0
***** Signal mux_2level_size50[56]->in[28] density = 0, probability=0.*****
Vmux_2level_size50[56]->in[28] mux_2level_size50[56]->in[28] 0
+  0
***** Signal mux_2level_size50[56]->in[29] density = 0, probability=0.*****
Vmux_2level_size50[56]->in[29] mux_2level_size50[56]->in[29] 0
+  0
***** Signal mux_2level_size50[56]->in[30] density = 0, probability=0.*****
Vmux_2level_size50[56]->in[30] mux_2level_size50[56]->in[30] 0
+  0
***** Signal mux_2level_size50[56]->in[31] density = 0, probability=0.*****
Vmux_2level_size50[56]->in[31] mux_2level_size50[56]->in[31] 0
+  0
***** Signal mux_2level_size50[56]->in[32] density = 0, probability=0.*****
Vmux_2level_size50[56]->in[32] mux_2level_size50[56]->in[32] 0
+  0
***** Signal mux_2level_size50[56]->in[33] density = 0, probability=0.*****
Vmux_2level_size50[56]->in[33] mux_2level_size50[56]->in[33] 0
+  0
***** Signal mux_2level_size50[56]->in[34] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[56]->in[34] mux_2level_size50[56]->in[34] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[56]->in[35] density = 0, probability=0.*****
Vmux_2level_size50[56]->in[35] mux_2level_size50[56]->in[35] 0
+  0
***** Signal mux_2level_size50[56]->in[36] density = 0, probability=0.*****
Vmux_2level_size50[56]->in[36] mux_2level_size50[56]->in[36] 0
+  0
***** Signal mux_2level_size50[56]->in[37] density = 0, probability=0.*****
Vmux_2level_size50[56]->in[37] mux_2level_size50[56]->in[37] 0
+  0
***** Signal mux_2level_size50[56]->in[38] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[56]->in[38] mux_2level_size50[56]->in[38] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[56]->in[39] density = 0, probability=0.*****
Vmux_2level_size50[56]->in[39] mux_2level_size50[56]->in[39] 0
+  0
***** Signal mux_2level_size50[56]->in[40] density = 0, probability=0.*****
Vmux_2level_size50[56]->in[40] mux_2level_size50[56]->in[40] 0
+  0
***** Signal mux_2level_size50[56]->in[41] density = 0, probability=0.*****
Vmux_2level_size50[56]->in[41] mux_2level_size50[56]->in[41] 0
+  0
***** Signal mux_2level_size50[56]->in[42] density = 0, probability=0.*****
Vmux_2level_size50[56]->in[42] mux_2level_size50[56]->in[42] 0
+  0
***** Signal mux_2level_size50[56]->in[43] density = 0, probability=0.*****
Vmux_2level_size50[56]->in[43] mux_2level_size50[56]->in[43] 0
+  0
***** Signal mux_2level_size50[56]->in[44] density = 0, probability=0.*****
Vmux_2level_size50[56]->in[44] mux_2level_size50[56]->in[44] 0
+  0
***** Signal mux_2level_size50[56]->in[45] density = 0, probability=0.*****
Vmux_2level_size50[56]->in[45] mux_2level_size50[56]->in[45] 0
+  0
***** Signal mux_2level_size50[56]->in[46] density = 0, probability=0.*****
Vmux_2level_size50[56]->in[46] mux_2level_size50[56]->in[46] 0
+  0
***** Signal mux_2level_size50[56]->in[47] density = 0, probability=0.*****
Vmux_2level_size50[56]->in[47] mux_2level_size50[56]->in[47] 0
+  0
***** Signal mux_2level_size50[56]->in[48] density = 0, probability=0.*****
Vmux_2level_size50[56]->in[48] mux_2level_size50[56]->in[48] 0
+  0
***** Signal mux_2level_size50[56]->in[49] density = 0.2026, probability=0.4982.*****
Vmux_2level_size50[56]->in[49] mux_2level_size50[56]->in[49] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.4982*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
Vgvdd_mux_2level_size50[56] gvdd_mux_2level_size50[56] 0 vsp
***** Measurements *****
***** Rise delay *****
.meas tran delay_rise_grid[1][1]_clb[0]_mode[clb]_fle[9]_mode[n1_lut6]_in[2]_crossbar trig v(mux_2level_size50[56]->in[0]) val='input_thres_pct_rise*vsp' rise=1 td='clock_period'
+          targ v(mux_2level_size50[56]->out) val='output_thres_pct_rise*vsp' rise=1 td='clock_period'
***** Fall delay *****
.meas tran delay_fall_grid[1][1]_clb[0]_mode[clb]_fle[9]_mode[n1_lut6]_in[2]_crossbar trig v(mux_2level_size50[56]->in[0]) val='input_thres_pct_fall*vsp' fall=1 td='clock_period'
+          targ v(mux_2level_size50[56]->out) val='output_thres_pct_fall*vsp' fall=1 td='clock_period'
***** Rise timing period *****
.meas start_rise_grid[1][1]_clb[0]_mode[clb]_fle[9]_mode[n1_lut6]_in[2]_crossbar when v(mux_2level_size50[56]->in[0])='slew_lower_thres_pct_rise*vsp' rise=1 td='clock_period'
.meas tran switch_rise_grid[1][1]_clb[0]_mode[clb]_fle[9]_mode[n1_lut6]_in[2]_crossbar trig v(mux_2level_size50[56]->in[0]) val='slew_lower_thres_pct_rise*vsp' rise=1 td='clock_period'
+          targ v(mux_2level_size50[56]->out) val='slew_upper_thres_pct_rise*vsp' rise=1 td='clock_period'
***** Fall timing period *****
.meas start_fall_grid[1][1]_clb[0]_mode[clb]_fle[9]_mode[n1_lut6]_in[2]_crossbar when v(mux_2level_size50[56]->in[0])='slew_lower_thres_pct_fall*vsp' fall=1 td='clock_period'
.meas tran switch_fall_grid[1][1]_clb[0]_mode[clb]_fle[9]_mode[n1_lut6]_in[2]_crossbar trig v(mux_2level_size50[56]->in[0]) val='slew_lower_thres_pct_fall*vsp' fall=1 td='clock_period'
+          targ v(mux_2level_size50[56]->out) val='slew_upper_thres_pct_fall*vsp' fall=1 td='clock_period'
***** Leakage Power Measurement *****
.meas tran mux_2level_size50[56]_leakage_power avg p(Vgvdd_mux_2level_size50[56]) from=0 to='clock_period'
.meas tran leakage_grid[1][1]_clb[0]_mode[clb]_fle[9]_mode[n1_lut6]_in[2]_crossbar param='mux_2level_size50[56]_leakage_power'
***** Dynamic Power Measurement *****
.meas tran mux_2level_size50[56]_dynamic_power avg p(Vgvdd_mux_2level_size50[56]) from='clock_period' to='6*clock_period'
.meas tran mux_2level_size50[56]_energy_per_cycle param='mux_2level_size50[56]_dynamic_power*clock_period'
.meas tran dynamic_power_grid[1][1]_clb[0]_mode[clb]_fle[9]_mode[n1_lut6]_in[2]_crossbar  param='mux_2level_size50[56]_dynamic_power'
.meas tran energy_per_cycle_grid[1][1]_clb[0]_mode[clb]_fle[9]_mode[n1_lut6]_in[2]_crossbar  param='dynamic_power_grid[1][1]_clb[0]_mode[clb]_fle[9]_mode[n1_lut6]_in[2]_crossbar*clock_period'
.meas tran dynamic_rise_grid[1][1]_clb[0]_mode[clb]_fle[9]_mode[n1_lut6]_in[2]_crossbar avg p(Vgvdd_mux_2level_size50[56]) from='start_rise_grid[1][1]_clb[0]_mode[clb]_fle[9]_mode[n1_lut6]_in[2]_crossbar' to='start_rise_grid[1][1]_clb[0]_mode[clb]_fle[9]_mode[n1_lut6]_in[2]_crossbar+switch_rise_grid[1][1]_clb[0]_mode[clb]_fle[9]_mode[n1_lut6]_in[2]_crossbar'
.meas tran dynamic_fall_grid[1][1]_clb[0]_mode[clb]_fle[9]_mode[n1_lut6]_in[2]_crossbar avg p(Vgvdd_mux_2level_size50[56]) from='start_fall_grid[1][1]_clb[0]_mode[clb]_fle[9]_mode[n1_lut6]_in[2]_crossbar' to='start_fall_grid[1][1]_clb[0]_mode[clb]_fle[9]_mode[n1_lut6]_in[2]_crossbar+switch_fall_grid[1][1]_clb[0]_mode[clb]_fle[9]_mode[n1_lut6]_in[2]_crossbar'
.meas tran sum_leakage_power_mux[0to56]
+          param='sum_leakage_power_mux[0to55]+leakage_grid[1][1]_clb[0]_mode[clb]_fle[9]_mode[n1_lut6]_in[2]_crossbar'
.meas tran sum_energy_per_cycle_mux[0to56]
+          param='sum_energy_per_cycle_mux[0to55]+energy_per_cycle_grid[1][1]_clb[0]_mode[clb]_fle[9]_mode[n1_lut6]_in[2]_crossbar'
Xload_inv[56]_no0 mux_2level_size50[56]->out mux_2level_size50[56]->out_out[0] gvdd_load 0 inv size=5
.meas tran sum_leakage_power_pb_mux[0to56]
+          param='sum_leakage_power_pb_mux[0to55]+leakage_grid[1][1]_clb[0]_mode[clb]_fle[9]_mode[n1_lut6]_in[2]_crossbar'
.meas tran sum_energy_per_cycle_pb_mux[0to56]
+          param='sum_energy_per_cycle_pb_mux[0to55]+energy_per_cycle_grid[1][1]_clb[0]_mode[clb]_fle[9]_mode[n1_lut6]_in[2]_crossbar'
Xmux_2level_size50[57] mux_2level_size50[57]->in[0] mux_2level_size50[57]->in[1] mux_2level_size50[57]->in[2] mux_2level_size50[57]->in[3] mux_2level_size50[57]->in[4] mux_2level_size50[57]->in[5] mux_2level_size50[57]->in[6] mux_2level_size50[57]->in[7] mux_2level_size50[57]->in[8] mux_2level_size50[57]->in[9] mux_2level_size50[57]->in[10] mux_2level_size50[57]->in[11] mux_2level_size50[57]->in[12] mux_2level_size50[57]->in[13] mux_2level_size50[57]->in[14] mux_2level_size50[57]->in[15] mux_2level_size50[57]->in[16] mux_2level_size50[57]->in[17] mux_2level_size50[57]->in[18] mux_2level_size50[57]->in[19] mux_2level_size50[57]->in[20] mux_2level_size50[57]->in[21] mux_2level_size50[57]->in[22] mux_2level_size50[57]->in[23] mux_2level_size50[57]->in[24] mux_2level_size50[57]->in[25] mux_2level_size50[57]->in[26] mux_2level_size50[57]->in[27] mux_2level_size50[57]->in[28] mux_2level_size50[57]->in[29] mux_2level_size50[57]->in[30] mux_2level_size50[57]->in[31] mux_2level_size50[57]->in[32] mux_2level_size50[57]->in[33] mux_2level_size50[57]->in[34] mux_2level_size50[57]->in[35] mux_2level_size50[57]->in[36] mux_2level_size50[57]->in[37] mux_2level_size50[57]->in[38] mux_2level_size50[57]->in[39] mux_2level_size50[57]->in[40] mux_2level_size50[57]->in[41] mux_2level_size50[57]->in[42] mux_2level_size50[57]->in[43] mux_2level_size50[57]->in[44] mux_2level_size50[57]->in[45] mux_2level_size50[57]->in[46] mux_2level_size50[57]->in[47] mux_2level_size50[57]->in[48] mux_2level_size50[57]->in[49] mux_2level_size50[57]->out sram[912]->outb sram[912]->out sram[913]->out sram[913]->outb sram[914]->out sram[914]->outb sram[915]->out sram[915]->outb sram[916]->out sram[916]->outb sram[917]->out sram[917]->outb sram[918]->out sram[918]->outb sram[919]->out sram[919]->outb sram[920]->outb sram[920]->out sram[921]->out sram[921]->outb sram[922]->out sram[922]->outb sram[923]->out sram[923]->outb sram[924]->out sram[924]->outb sram[925]->out sram[925]->outb sram[926]->out sram[926]->outb sram[927]->out sram[927]->outb gvdd_mux_2level_size50[57] 0 mux_2level_size50
***** SRAM bits for MUX[57], level=2, select_path_id=0. *****
*****1000000010000000*****
Xsram[912] sram->in sram[912]->out sram[912]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[912]->out) 0
.nodeset V(sram[912]->outb) vsp
Xsram[913] sram->in sram[913]->out sram[913]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[913]->out) 0
.nodeset V(sram[913]->outb) vsp
Xsram[914] sram->in sram[914]->out sram[914]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[914]->out) 0
.nodeset V(sram[914]->outb) vsp
Xsram[915] sram->in sram[915]->out sram[915]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[915]->out) 0
.nodeset V(sram[915]->outb) vsp
Xsram[916] sram->in sram[916]->out sram[916]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[916]->out) 0
.nodeset V(sram[916]->outb) vsp
Xsram[917] sram->in sram[917]->out sram[917]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[917]->out) 0
.nodeset V(sram[917]->outb) vsp
Xsram[918] sram->in sram[918]->out sram[918]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[918]->out) 0
.nodeset V(sram[918]->outb) vsp
Xsram[919] sram->in sram[919]->out sram[919]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[919]->out) 0
.nodeset V(sram[919]->outb) vsp
Xsram[920] sram->in sram[920]->out sram[920]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[920]->out) 0
.nodeset V(sram[920]->outb) vsp
Xsram[921] sram->in sram[921]->out sram[921]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[921]->out) 0
.nodeset V(sram[921]->outb) vsp
Xsram[922] sram->in sram[922]->out sram[922]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[922]->out) 0
.nodeset V(sram[922]->outb) vsp
Xsram[923] sram->in sram[923]->out sram[923]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[923]->out) 0
.nodeset V(sram[923]->outb) vsp
Xsram[924] sram->in sram[924]->out sram[924]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[924]->out) 0
.nodeset V(sram[924]->outb) vsp
Xsram[925] sram->in sram[925]->out sram[925]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[925]->out) 0
.nodeset V(sram[925]->outb) vsp
Xsram[926] sram->in sram[926]->out sram[926]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[926]->out) 0
.nodeset V(sram[926]->outb) vsp
Xsram[927] sram->in sram[927]->out sram[927]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[927]->out) 0
.nodeset V(sram[927]->outb) vsp
***** Signal mux_2level_size50[57]->in[0] density = 0, probability=0.*****
Vmux_2level_size50[57]->in[0] mux_2level_size50[57]->in[0] 0
+  0
***** Signal mux_2level_size50[57]->in[1] density = 0, probability=0.*****
Vmux_2level_size50[57]->in[1] mux_2level_size50[57]->in[1] 0
+  0
***** Signal mux_2level_size50[57]->in[2] density = 0, probability=0.*****
Vmux_2level_size50[57]->in[2] mux_2level_size50[57]->in[2] 0
+  0
***** Signal mux_2level_size50[57]->in[3] density = 0, probability=0.*****
Vmux_2level_size50[57]->in[3] mux_2level_size50[57]->in[3] 0
+  0
***** Signal mux_2level_size50[57]->in[4] density = 0, probability=0.*****
Vmux_2level_size50[57]->in[4] mux_2level_size50[57]->in[4] 0
+  0
***** Signal mux_2level_size50[57]->in[5] density = 0, probability=0.*****
Vmux_2level_size50[57]->in[5] mux_2level_size50[57]->in[5] 0
+  0
***** Signal mux_2level_size50[57]->in[6] density = 0, probability=0.*****
Vmux_2level_size50[57]->in[6] mux_2level_size50[57]->in[6] 0
+  0
***** Signal mux_2level_size50[57]->in[7] density = 0, probability=0.*****
Vmux_2level_size50[57]->in[7] mux_2level_size50[57]->in[7] 0
+  0
***** Signal mux_2level_size50[57]->in[8] density = 0, probability=0.*****
Vmux_2level_size50[57]->in[8] mux_2level_size50[57]->in[8] 0
+  0
***** Signal mux_2level_size50[57]->in[9] density = 0, probability=0.*****
Vmux_2level_size50[57]->in[9] mux_2level_size50[57]->in[9] 0
+  0
***** Signal mux_2level_size50[57]->in[10] density = 0, probability=0.*****
Vmux_2level_size50[57]->in[10] mux_2level_size50[57]->in[10] 0
+  0
***** Signal mux_2level_size50[57]->in[11] density = 0, probability=0.*****
Vmux_2level_size50[57]->in[11] mux_2level_size50[57]->in[11] 0
+  0
***** Signal mux_2level_size50[57]->in[12] density = 0, probability=0.*****
Vmux_2level_size50[57]->in[12] mux_2level_size50[57]->in[12] 0
+  0
***** Signal mux_2level_size50[57]->in[13] density = 0, probability=0.*****
Vmux_2level_size50[57]->in[13] mux_2level_size50[57]->in[13] 0
+  0
***** Signal mux_2level_size50[57]->in[14] density = 0, probability=0.*****
Vmux_2level_size50[57]->in[14] mux_2level_size50[57]->in[14] 0
+  0
***** Signal mux_2level_size50[57]->in[15] density = 0, probability=0.*****
Vmux_2level_size50[57]->in[15] mux_2level_size50[57]->in[15] 0
+  0
***** Signal mux_2level_size50[57]->in[16] density = 0, probability=0.*****
Vmux_2level_size50[57]->in[16] mux_2level_size50[57]->in[16] 0
+  0
***** Signal mux_2level_size50[57]->in[17] density = 0, probability=0.*****
Vmux_2level_size50[57]->in[17] mux_2level_size50[57]->in[17] 0
+  0
***** Signal mux_2level_size50[57]->in[18] density = 0, probability=0.*****
Vmux_2level_size50[57]->in[18] mux_2level_size50[57]->in[18] 0
+  0
***** Signal mux_2level_size50[57]->in[19] density = 0, probability=0.*****
Vmux_2level_size50[57]->in[19] mux_2level_size50[57]->in[19] 0
+  0
***** Signal mux_2level_size50[57]->in[20] density = 0, probability=0.*****
Vmux_2level_size50[57]->in[20] mux_2level_size50[57]->in[20] 0
+  0
***** Signal mux_2level_size50[57]->in[21] density = 0, probability=0.*****
Vmux_2level_size50[57]->in[21] mux_2level_size50[57]->in[21] 0
+  0
***** Signal mux_2level_size50[57]->in[22] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[57]->in[22] mux_2level_size50[57]->in[22] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[57]->in[23] density = 0, probability=0.*****
Vmux_2level_size50[57]->in[23] mux_2level_size50[57]->in[23] 0
+  0
***** Signal mux_2level_size50[57]->in[24] density = 0, probability=0.*****
Vmux_2level_size50[57]->in[24] mux_2level_size50[57]->in[24] 0
+  0
***** Signal mux_2level_size50[57]->in[25] density = 0, probability=0.*****
Vmux_2level_size50[57]->in[25] mux_2level_size50[57]->in[25] 0
+  0
***** Signal mux_2level_size50[57]->in[26] density = 0, probability=0.*****
Vmux_2level_size50[57]->in[26] mux_2level_size50[57]->in[26] 0
+  0
***** Signal mux_2level_size50[57]->in[27] density = 0, probability=0.*****
Vmux_2level_size50[57]->in[27] mux_2level_size50[57]->in[27] 0
+  0
***** Signal mux_2level_size50[57]->in[28] density = 0, probability=0.*****
Vmux_2level_size50[57]->in[28] mux_2level_size50[57]->in[28] 0
+  0
***** Signal mux_2level_size50[57]->in[29] density = 0, probability=0.*****
Vmux_2level_size50[57]->in[29] mux_2level_size50[57]->in[29] 0
+  0
***** Signal mux_2level_size50[57]->in[30] density = 0, probability=0.*****
Vmux_2level_size50[57]->in[30] mux_2level_size50[57]->in[30] 0
+  0
***** Signal mux_2level_size50[57]->in[31] density = 0, probability=0.*****
Vmux_2level_size50[57]->in[31] mux_2level_size50[57]->in[31] 0
+  0
***** Signal mux_2level_size50[57]->in[32] density = 0, probability=0.*****
Vmux_2level_size50[57]->in[32] mux_2level_size50[57]->in[32] 0
+  0
***** Signal mux_2level_size50[57]->in[33] density = 0, probability=0.*****
Vmux_2level_size50[57]->in[33] mux_2level_size50[57]->in[33] 0
+  0
***** Signal mux_2level_size50[57]->in[34] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[57]->in[34] mux_2level_size50[57]->in[34] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[57]->in[35] density = 0, probability=0.*****
Vmux_2level_size50[57]->in[35] mux_2level_size50[57]->in[35] 0
+  0
***** Signal mux_2level_size50[57]->in[36] density = 0, probability=0.*****
Vmux_2level_size50[57]->in[36] mux_2level_size50[57]->in[36] 0
+  0
***** Signal mux_2level_size50[57]->in[37] density = 0, probability=0.*****
Vmux_2level_size50[57]->in[37] mux_2level_size50[57]->in[37] 0
+  0
***** Signal mux_2level_size50[57]->in[38] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[57]->in[38] mux_2level_size50[57]->in[38] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[57]->in[39] density = 0, probability=0.*****
Vmux_2level_size50[57]->in[39] mux_2level_size50[57]->in[39] 0
+  0
***** Signal mux_2level_size50[57]->in[40] density = 0, probability=0.*****
Vmux_2level_size50[57]->in[40] mux_2level_size50[57]->in[40] 0
+  0
***** Signal mux_2level_size50[57]->in[41] density = 0, probability=0.*****
Vmux_2level_size50[57]->in[41] mux_2level_size50[57]->in[41] 0
+  0
***** Signal mux_2level_size50[57]->in[42] density = 0, probability=0.*****
Vmux_2level_size50[57]->in[42] mux_2level_size50[57]->in[42] 0
+  0
***** Signal mux_2level_size50[57]->in[43] density = 0, probability=0.*****
Vmux_2level_size50[57]->in[43] mux_2level_size50[57]->in[43] 0
+  0
***** Signal mux_2level_size50[57]->in[44] density = 0, probability=0.*****
Vmux_2level_size50[57]->in[44] mux_2level_size50[57]->in[44] 0
+  0
***** Signal mux_2level_size50[57]->in[45] density = 0, probability=0.*****
Vmux_2level_size50[57]->in[45] mux_2level_size50[57]->in[45] 0
+  0
***** Signal mux_2level_size50[57]->in[46] density = 0, probability=0.*****
Vmux_2level_size50[57]->in[46] mux_2level_size50[57]->in[46] 0
+  0
***** Signal mux_2level_size50[57]->in[47] density = 0, probability=0.*****
Vmux_2level_size50[57]->in[47] mux_2level_size50[57]->in[47] 0
+  0
***** Signal mux_2level_size50[57]->in[48] density = 0, probability=0.*****
Vmux_2level_size50[57]->in[48] mux_2level_size50[57]->in[48] 0
+  0
***** Signal mux_2level_size50[57]->in[49] density = 0.2026, probability=0.4982.*****
Vmux_2level_size50[57]->in[49] mux_2level_size50[57]->in[49] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.4982*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
Vgvdd_mux_2level_size50[57] gvdd_mux_2level_size50[57] 0 vsp
***** Measurements *****
***** Rise delay *****
.meas tran delay_rise_grid[1][1]_clb[0]_mode[clb]_fle[9]_mode[n1_lut6]_in[3]_crossbar trig v(mux_2level_size50[57]->in[0]) val='input_thres_pct_rise*vsp' rise=1 td='clock_period'
+          targ v(mux_2level_size50[57]->out) val='output_thres_pct_rise*vsp' rise=1 td='clock_period'
***** Fall delay *****
.meas tran delay_fall_grid[1][1]_clb[0]_mode[clb]_fle[9]_mode[n1_lut6]_in[3]_crossbar trig v(mux_2level_size50[57]->in[0]) val='input_thres_pct_fall*vsp' fall=1 td='clock_period'
+          targ v(mux_2level_size50[57]->out) val='output_thres_pct_fall*vsp' fall=1 td='clock_period'
***** Rise timing period *****
.meas start_rise_grid[1][1]_clb[0]_mode[clb]_fle[9]_mode[n1_lut6]_in[3]_crossbar when v(mux_2level_size50[57]->in[0])='slew_lower_thres_pct_rise*vsp' rise=1 td='clock_period'
.meas tran switch_rise_grid[1][1]_clb[0]_mode[clb]_fle[9]_mode[n1_lut6]_in[3]_crossbar trig v(mux_2level_size50[57]->in[0]) val='slew_lower_thres_pct_rise*vsp' rise=1 td='clock_period'
+          targ v(mux_2level_size50[57]->out) val='slew_upper_thres_pct_rise*vsp' rise=1 td='clock_period'
***** Fall timing period *****
.meas start_fall_grid[1][1]_clb[0]_mode[clb]_fle[9]_mode[n1_lut6]_in[3]_crossbar when v(mux_2level_size50[57]->in[0])='slew_lower_thres_pct_fall*vsp' fall=1 td='clock_period'
.meas tran switch_fall_grid[1][1]_clb[0]_mode[clb]_fle[9]_mode[n1_lut6]_in[3]_crossbar trig v(mux_2level_size50[57]->in[0]) val='slew_lower_thres_pct_fall*vsp' fall=1 td='clock_period'
+          targ v(mux_2level_size50[57]->out) val='slew_upper_thres_pct_fall*vsp' fall=1 td='clock_period'
***** Leakage Power Measurement *****
.meas tran mux_2level_size50[57]_leakage_power avg p(Vgvdd_mux_2level_size50[57]) from=0 to='clock_period'
.meas tran leakage_grid[1][1]_clb[0]_mode[clb]_fle[9]_mode[n1_lut6]_in[3]_crossbar param='mux_2level_size50[57]_leakage_power'
***** Dynamic Power Measurement *****
.meas tran mux_2level_size50[57]_dynamic_power avg p(Vgvdd_mux_2level_size50[57]) from='clock_period' to='6*clock_period'
.meas tran mux_2level_size50[57]_energy_per_cycle param='mux_2level_size50[57]_dynamic_power*clock_period'
.meas tran dynamic_power_grid[1][1]_clb[0]_mode[clb]_fle[9]_mode[n1_lut6]_in[3]_crossbar  param='mux_2level_size50[57]_dynamic_power'
.meas tran energy_per_cycle_grid[1][1]_clb[0]_mode[clb]_fle[9]_mode[n1_lut6]_in[3]_crossbar  param='dynamic_power_grid[1][1]_clb[0]_mode[clb]_fle[9]_mode[n1_lut6]_in[3]_crossbar*clock_period'
.meas tran dynamic_rise_grid[1][1]_clb[0]_mode[clb]_fle[9]_mode[n1_lut6]_in[3]_crossbar avg p(Vgvdd_mux_2level_size50[57]) from='start_rise_grid[1][1]_clb[0]_mode[clb]_fle[9]_mode[n1_lut6]_in[3]_crossbar' to='start_rise_grid[1][1]_clb[0]_mode[clb]_fle[9]_mode[n1_lut6]_in[3]_crossbar+switch_rise_grid[1][1]_clb[0]_mode[clb]_fle[9]_mode[n1_lut6]_in[3]_crossbar'
.meas tran dynamic_fall_grid[1][1]_clb[0]_mode[clb]_fle[9]_mode[n1_lut6]_in[3]_crossbar avg p(Vgvdd_mux_2level_size50[57]) from='start_fall_grid[1][1]_clb[0]_mode[clb]_fle[9]_mode[n1_lut6]_in[3]_crossbar' to='start_fall_grid[1][1]_clb[0]_mode[clb]_fle[9]_mode[n1_lut6]_in[3]_crossbar+switch_fall_grid[1][1]_clb[0]_mode[clb]_fle[9]_mode[n1_lut6]_in[3]_crossbar'
.meas tran sum_leakage_power_mux[0to57]
+          param='sum_leakage_power_mux[0to56]+leakage_grid[1][1]_clb[0]_mode[clb]_fle[9]_mode[n1_lut6]_in[3]_crossbar'
.meas tran sum_energy_per_cycle_mux[0to57]
+          param='sum_energy_per_cycle_mux[0to56]+energy_per_cycle_grid[1][1]_clb[0]_mode[clb]_fle[9]_mode[n1_lut6]_in[3]_crossbar'
Xload_inv[57]_no0 mux_2level_size50[57]->out mux_2level_size50[57]->out_out[0] gvdd_load 0 inv size=5
.meas tran sum_leakage_power_pb_mux[0to57]
+          param='sum_leakage_power_pb_mux[0to56]+leakage_grid[1][1]_clb[0]_mode[clb]_fle[9]_mode[n1_lut6]_in[3]_crossbar'
.meas tran sum_energy_per_cycle_pb_mux[0to57]
+          param='sum_energy_per_cycle_pb_mux[0to56]+energy_per_cycle_grid[1][1]_clb[0]_mode[clb]_fle[9]_mode[n1_lut6]_in[3]_crossbar'
Xmux_2level_size50[58] mux_2level_size50[58]->in[0] mux_2level_size50[58]->in[1] mux_2level_size50[58]->in[2] mux_2level_size50[58]->in[3] mux_2level_size50[58]->in[4] mux_2level_size50[58]->in[5] mux_2level_size50[58]->in[6] mux_2level_size50[58]->in[7] mux_2level_size50[58]->in[8] mux_2level_size50[58]->in[9] mux_2level_size50[58]->in[10] mux_2level_size50[58]->in[11] mux_2level_size50[58]->in[12] mux_2level_size50[58]->in[13] mux_2level_size50[58]->in[14] mux_2level_size50[58]->in[15] mux_2level_size50[58]->in[16] mux_2level_size50[58]->in[17] mux_2level_size50[58]->in[18] mux_2level_size50[58]->in[19] mux_2level_size50[58]->in[20] mux_2level_size50[58]->in[21] mux_2level_size50[58]->in[22] mux_2level_size50[58]->in[23] mux_2level_size50[58]->in[24] mux_2level_size50[58]->in[25] mux_2level_size50[58]->in[26] mux_2level_size50[58]->in[27] mux_2level_size50[58]->in[28] mux_2level_size50[58]->in[29] mux_2level_size50[58]->in[30] mux_2level_size50[58]->in[31] mux_2level_size50[58]->in[32] mux_2level_size50[58]->in[33] mux_2level_size50[58]->in[34] mux_2level_size50[58]->in[35] mux_2level_size50[58]->in[36] mux_2level_size50[58]->in[37] mux_2level_size50[58]->in[38] mux_2level_size50[58]->in[39] mux_2level_size50[58]->in[40] mux_2level_size50[58]->in[41] mux_2level_size50[58]->in[42] mux_2level_size50[58]->in[43] mux_2level_size50[58]->in[44] mux_2level_size50[58]->in[45] mux_2level_size50[58]->in[46] mux_2level_size50[58]->in[47] mux_2level_size50[58]->in[48] mux_2level_size50[58]->in[49] mux_2level_size50[58]->out sram[928]->outb sram[928]->out sram[929]->out sram[929]->outb sram[930]->out sram[930]->outb sram[931]->out sram[931]->outb sram[932]->out sram[932]->outb sram[933]->out sram[933]->outb sram[934]->out sram[934]->outb sram[935]->out sram[935]->outb sram[936]->outb sram[936]->out sram[937]->out sram[937]->outb sram[938]->out sram[938]->outb sram[939]->out sram[939]->outb sram[940]->out sram[940]->outb sram[941]->out sram[941]->outb sram[942]->out sram[942]->outb sram[943]->out sram[943]->outb gvdd_mux_2level_size50[58] 0 mux_2level_size50
***** SRAM bits for MUX[58], level=2, select_path_id=0. *****
*****1000000010000000*****
Xsram[928] sram->in sram[928]->out sram[928]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[928]->out) 0
.nodeset V(sram[928]->outb) vsp
Xsram[929] sram->in sram[929]->out sram[929]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[929]->out) 0
.nodeset V(sram[929]->outb) vsp
Xsram[930] sram->in sram[930]->out sram[930]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[930]->out) 0
.nodeset V(sram[930]->outb) vsp
Xsram[931] sram->in sram[931]->out sram[931]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[931]->out) 0
.nodeset V(sram[931]->outb) vsp
Xsram[932] sram->in sram[932]->out sram[932]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[932]->out) 0
.nodeset V(sram[932]->outb) vsp
Xsram[933] sram->in sram[933]->out sram[933]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[933]->out) 0
.nodeset V(sram[933]->outb) vsp
Xsram[934] sram->in sram[934]->out sram[934]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[934]->out) 0
.nodeset V(sram[934]->outb) vsp
Xsram[935] sram->in sram[935]->out sram[935]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[935]->out) 0
.nodeset V(sram[935]->outb) vsp
Xsram[936] sram->in sram[936]->out sram[936]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[936]->out) 0
.nodeset V(sram[936]->outb) vsp
Xsram[937] sram->in sram[937]->out sram[937]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[937]->out) 0
.nodeset V(sram[937]->outb) vsp
Xsram[938] sram->in sram[938]->out sram[938]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[938]->out) 0
.nodeset V(sram[938]->outb) vsp
Xsram[939] sram->in sram[939]->out sram[939]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[939]->out) 0
.nodeset V(sram[939]->outb) vsp
Xsram[940] sram->in sram[940]->out sram[940]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[940]->out) 0
.nodeset V(sram[940]->outb) vsp
Xsram[941] sram->in sram[941]->out sram[941]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[941]->out) 0
.nodeset V(sram[941]->outb) vsp
Xsram[942] sram->in sram[942]->out sram[942]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[942]->out) 0
.nodeset V(sram[942]->outb) vsp
Xsram[943] sram->in sram[943]->out sram[943]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[943]->out) 0
.nodeset V(sram[943]->outb) vsp
***** Signal mux_2level_size50[58]->in[0] density = 0, probability=0.*****
Vmux_2level_size50[58]->in[0] mux_2level_size50[58]->in[0] 0
+  0
***** Signal mux_2level_size50[58]->in[1] density = 0, probability=0.*****
Vmux_2level_size50[58]->in[1] mux_2level_size50[58]->in[1] 0
+  0
***** Signal mux_2level_size50[58]->in[2] density = 0, probability=0.*****
Vmux_2level_size50[58]->in[2] mux_2level_size50[58]->in[2] 0
+  0
***** Signal mux_2level_size50[58]->in[3] density = 0, probability=0.*****
Vmux_2level_size50[58]->in[3] mux_2level_size50[58]->in[3] 0
+  0
***** Signal mux_2level_size50[58]->in[4] density = 0, probability=0.*****
Vmux_2level_size50[58]->in[4] mux_2level_size50[58]->in[4] 0
+  0
***** Signal mux_2level_size50[58]->in[5] density = 0, probability=0.*****
Vmux_2level_size50[58]->in[5] mux_2level_size50[58]->in[5] 0
+  0
***** Signal mux_2level_size50[58]->in[6] density = 0, probability=0.*****
Vmux_2level_size50[58]->in[6] mux_2level_size50[58]->in[6] 0
+  0
***** Signal mux_2level_size50[58]->in[7] density = 0, probability=0.*****
Vmux_2level_size50[58]->in[7] mux_2level_size50[58]->in[7] 0
+  0
***** Signal mux_2level_size50[58]->in[8] density = 0, probability=0.*****
Vmux_2level_size50[58]->in[8] mux_2level_size50[58]->in[8] 0
+  0
***** Signal mux_2level_size50[58]->in[9] density = 0, probability=0.*****
Vmux_2level_size50[58]->in[9] mux_2level_size50[58]->in[9] 0
+  0
***** Signal mux_2level_size50[58]->in[10] density = 0, probability=0.*****
Vmux_2level_size50[58]->in[10] mux_2level_size50[58]->in[10] 0
+  0
***** Signal mux_2level_size50[58]->in[11] density = 0, probability=0.*****
Vmux_2level_size50[58]->in[11] mux_2level_size50[58]->in[11] 0
+  0
***** Signal mux_2level_size50[58]->in[12] density = 0, probability=0.*****
Vmux_2level_size50[58]->in[12] mux_2level_size50[58]->in[12] 0
+  0
***** Signal mux_2level_size50[58]->in[13] density = 0, probability=0.*****
Vmux_2level_size50[58]->in[13] mux_2level_size50[58]->in[13] 0
+  0
***** Signal mux_2level_size50[58]->in[14] density = 0, probability=0.*****
Vmux_2level_size50[58]->in[14] mux_2level_size50[58]->in[14] 0
+  0
***** Signal mux_2level_size50[58]->in[15] density = 0, probability=0.*****
Vmux_2level_size50[58]->in[15] mux_2level_size50[58]->in[15] 0
+  0
***** Signal mux_2level_size50[58]->in[16] density = 0, probability=0.*****
Vmux_2level_size50[58]->in[16] mux_2level_size50[58]->in[16] 0
+  0
***** Signal mux_2level_size50[58]->in[17] density = 0, probability=0.*****
Vmux_2level_size50[58]->in[17] mux_2level_size50[58]->in[17] 0
+  0
***** Signal mux_2level_size50[58]->in[18] density = 0, probability=0.*****
Vmux_2level_size50[58]->in[18] mux_2level_size50[58]->in[18] 0
+  0
***** Signal mux_2level_size50[58]->in[19] density = 0, probability=0.*****
Vmux_2level_size50[58]->in[19] mux_2level_size50[58]->in[19] 0
+  0
***** Signal mux_2level_size50[58]->in[20] density = 0, probability=0.*****
Vmux_2level_size50[58]->in[20] mux_2level_size50[58]->in[20] 0
+  0
***** Signal mux_2level_size50[58]->in[21] density = 0, probability=0.*****
Vmux_2level_size50[58]->in[21] mux_2level_size50[58]->in[21] 0
+  0
***** Signal mux_2level_size50[58]->in[22] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[58]->in[22] mux_2level_size50[58]->in[22] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[58]->in[23] density = 0, probability=0.*****
Vmux_2level_size50[58]->in[23] mux_2level_size50[58]->in[23] 0
+  0
***** Signal mux_2level_size50[58]->in[24] density = 0, probability=0.*****
Vmux_2level_size50[58]->in[24] mux_2level_size50[58]->in[24] 0
+  0
***** Signal mux_2level_size50[58]->in[25] density = 0, probability=0.*****
Vmux_2level_size50[58]->in[25] mux_2level_size50[58]->in[25] 0
+  0
***** Signal mux_2level_size50[58]->in[26] density = 0, probability=0.*****
Vmux_2level_size50[58]->in[26] mux_2level_size50[58]->in[26] 0
+  0
***** Signal mux_2level_size50[58]->in[27] density = 0, probability=0.*****
Vmux_2level_size50[58]->in[27] mux_2level_size50[58]->in[27] 0
+  0
***** Signal mux_2level_size50[58]->in[28] density = 0, probability=0.*****
Vmux_2level_size50[58]->in[28] mux_2level_size50[58]->in[28] 0
+  0
***** Signal mux_2level_size50[58]->in[29] density = 0, probability=0.*****
Vmux_2level_size50[58]->in[29] mux_2level_size50[58]->in[29] 0
+  0
***** Signal mux_2level_size50[58]->in[30] density = 0, probability=0.*****
Vmux_2level_size50[58]->in[30] mux_2level_size50[58]->in[30] 0
+  0
***** Signal mux_2level_size50[58]->in[31] density = 0, probability=0.*****
Vmux_2level_size50[58]->in[31] mux_2level_size50[58]->in[31] 0
+  0
***** Signal mux_2level_size50[58]->in[32] density = 0, probability=0.*****
Vmux_2level_size50[58]->in[32] mux_2level_size50[58]->in[32] 0
+  0
***** Signal mux_2level_size50[58]->in[33] density = 0, probability=0.*****
Vmux_2level_size50[58]->in[33] mux_2level_size50[58]->in[33] 0
+  0
***** Signal mux_2level_size50[58]->in[34] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[58]->in[34] mux_2level_size50[58]->in[34] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[58]->in[35] density = 0, probability=0.*****
Vmux_2level_size50[58]->in[35] mux_2level_size50[58]->in[35] 0
+  0
***** Signal mux_2level_size50[58]->in[36] density = 0, probability=0.*****
Vmux_2level_size50[58]->in[36] mux_2level_size50[58]->in[36] 0
+  0
***** Signal mux_2level_size50[58]->in[37] density = 0, probability=0.*****
Vmux_2level_size50[58]->in[37] mux_2level_size50[58]->in[37] 0
+  0
***** Signal mux_2level_size50[58]->in[38] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[58]->in[38] mux_2level_size50[58]->in[38] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[58]->in[39] density = 0, probability=0.*****
Vmux_2level_size50[58]->in[39] mux_2level_size50[58]->in[39] 0
+  0
***** Signal mux_2level_size50[58]->in[40] density = 0, probability=0.*****
Vmux_2level_size50[58]->in[40] mux_2level_size50[58]->in[40] 0
+  0
***** Signal mux_2level_size50[58]->in[41] density = 0, probability=0.*****
Vmux_2level_size50[58]->in[41] mux_2level_size50[58]->in[41] 0
+  0
***** Signal mux_2level_size50[58]->in[42] density = 0, probability=0.*****
Vmux_2level_size50[58]->in[42] mux_2level_size50[58]->in[42] 0
+  0
***** Signal mux_2level_size50[58]->in[43] density = 0, probability=0.*****
Vmux_2level_size50[58]->in[43] mux_2level_size50[58]->in[43] 0
+  0
***** Signal mux_2level_size50[58]->in[44] density = 0, probability=0.*****
Vmux_2level_size50[58]->in[44] mux_2level_size50[58]->in[44] 0
+  0
***** Signal mux_2level_size50[58]->in[45] density = 0, probability=0.*****
Vmux_2level_size50[58]->in[45] mux_2level_size50[58]->in[45] 0
+  0
***** Signal mux_2level_size50[58]->in[46] density = 0, probability=0.*****
Vmux_2level_size50[58]->in[46] mux_2level_size50[58]->in[46] 0
+  0
***** Signal mux_2level_size50[58]->in[47] density = 0, probability=0.*****
Vmux_2level_size50[58]->in[47] mux_2level_size50[58]->in[47] 0
+  0
***** Signal mux_2level_size50[58]->in[48] density = 0, probability=0.*****
Vmux_2level_size50[58]->in[48] mux_2level_size50[58]->in[48] 0
+  0
***** Signal mux_2level_size50[58]->in[49] density = 0.2026, probability=0.4982.*****
Vmux_2level_size50[58]->in[49] mux_2level_size50[58]->in[49] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.4982*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
Vgvdd_mux_2level_size50[58] gvdd_mux_2level_size50[58] 0 vsp
***** Measurements *****
***** Rise delay *****
.meas tran delay_rise_grid[1][1]_clb[0]_mode[clb]_fle[9]_mode[n1_lut6]_in[4]_crossbar trig v(mux_2level_size50[58]->in[0]) val='input_thres_pct_rise*vsp' rise=1 td='clock_period'
+          targ v(mux_2level_size50[58]->out) val='output_thres_pct_rise*vsp' rise=1 td='clock_period'
***** Fall delay *****
.meas tran delay_fall_grid[1][1]_clb[0]_mode[clb]_fle[9]_mode[n1_lut6]_in[4]_crossbar trig v(mux_2level_size50[58]->in[0]) val='input_thres_pct_fall*vsp' fall=1 td='clock_period'
+          targ v(mux_2level_size50[58]->out) val='output_thres_pct_fall*vsp' fall=1 td='clock_period'
***** Rise timing period *****
.meas start_rise_grid[1][1]_clb[0]_mode[clb]_fle[9]_mode[n1_lut6]_in[4]_crossbar when v(mux_2level_size50[58]->in[0])='slew_lower_thres_pct_rise*vsp' rise=1 td='clock_period'
.meas tran switch_rise_grid[1][1]_clb[0]_mode[clb]_fle[9]_mode[n1_lut6]_in[4]_crossbar trig v(mux_2level_size50[58]->in[0]) val='slew_lower_thres_pct_rise*vsp' rise=1 td='clock_period'
+          targ v(mux_2level_size50[58]->out) val='slew_upper_thres_pct_rise*vsp' rise=1 td='clock_period'
***** Fall timing period *****
.meas start_fall_grid[1][1]_clb[0]_mode[clb]_fle[9]_mode[n1_lut6]_in[4]_crossbar when v(mux_2level_size50[58]->in[0])='slew_lower_thres_pct_fall*vsp' fall=1 td='clock_period'
.meas tran switch_fall_grid[1][1]_clb[0]_mode[clb]_fle[9]_mode[n1_lut6]_in[4]_crossbar trig v(mux_2level_size50[58]->in[0]) val='slew_lower_thres_pct_fall*vsp' fall=1 td='clock_period'
+          targ v(mux_2level_size50[58]->out) val='slew_upper_thres_pct_fall*vsp' fall=1 td='clock_period'
***** Leakage Power Measurement *****
.meas tran mux_2level_size50[58]_leakage_power avg p(Vgvdd_mux_2level_size50[58]) from=0 to='clock_period'
.meas tran leakage_grid[1][1]_clb[0]_mode[clb]_fle[9]_mode[n1_lut6]_in[4]_crossbar param='mux_2level_size50[58]_leakage_power'
***** Dynamic Power Measurement *****
.meas tran mux_2level_size50[58]_dynamic_power avg p(Vgvdd_mux_2level_size50[58]) from='clock_period' to='6*clock_period'
.meas tran mux_2level_size50[58]_energy_per_cycle param='mux_2level_size50[58]_dynamic_power*clock_period'
.meas tran dynamic_power_grid[1][1]_clb[0]_mode[clb]_fle[9]_mode[n1_lut6]_in[4]_crossbar  param='mux_2level_size50[58]_dynamic_power'
.meas tran energy_per_cycle_grid[1][1]_clb[0]_mode[clb]_fle[9]_mode[n1_lut6]_in[4]_crossbar  param='dynamic_power_grid[1][1]_clb[0]_mode[clb]_fle[9]_mode[n1_lut6]_in[4]_crossbar*clock_period'
.meas tran dynamic_rise_grid[1][1]_clb[0]_mode[clb]_fle[9]_mode[n1_lut6]_in[4]_crossbar avg p(Vgvdd_mux_2level_size50[58]) from='start_rise_grid[1][1]_clb[0]_mode[clb]_fle[9]_mode[n1_lut6]_in[4]_crossbar' to='start_rise_grid[1][1]_clb[0]_mode[clb]_fle[9]_mode[n1_lut6]_in[4]_crossbar+switch_rise_grid[1][1]_clb[0]_mode[clb]_fle[9]_mode[n1_lut6]_in[4]_crossbar'
.meas tran dynamic_fall_grid[1][1]_clb[0]_mode[clb]_fle[9]_mode[n1_lut6]_in[4]_crossbar avg p(Vgvdd_mux_2level_size50[58]) from='start_fall_grid[1][1]_clb[0]_mode[clb]_fle[9]_mode[n1_lut6]_in[4]_crossbar' to='start_fall_grid[1][1]_clb[0]_mode[clb]_fle[9]_mode[n1_lut6]_in[4]_crossbar+switch_fall_grid[1][1]_clb[0]_mode[clb]_fle[9]_mode[n1_lut6]_in[4]_crossbar'
.meas tran sum_leakage_power_mux[0to58]
+          param='sum_leakage_power_mux[0to57]+leakage_grid[1][1]_clb[0]_mode[clb]_fle[9]_mode[n1_lut6]_in[4]_crossbar'
.meas tran sum_energy_per_cycle_mux[0to58]
+          param='sum_energy_per_cycle_mux[0to57]+energy_per_cycle_grid[1][1]_clb[0]_mode[clb]_fle[9]_mode[n1_lut6]_in[4]_crossbar'
Xload_inv[58]_no0 mux_2level_size50[58]->out mux_2level_size50[58]->out_out[0] gvdd_load 0 inv size=5
.meas tran sum_leakage_power_pb_mux[0to58]
+          param='sum_leakage_power_pb_mux[0to57]+leakage_grid[1][1]_clb[0]_mode[clb]_fle[9]_mode[n1_lut6]_in[4]_crossbar'
.meas tran sum_energy_per_cycle_pb_mux[0to58]
+          param='sum_energy_per_cycle_pb_mux[0to57]+energy_per_cycle_grid[1][1]_clb[0]_mode[clb]_fle[9]_mode[n1_lut6]_in[4]_crossbar'
Xmux_2level_size50[59] mux_2level_size50[59]->in[0] mux_2level_size50[59]->in[1] mux_2level_size50[59]->in[2] mux_2level_size50[59]->in[3] mux_2level_size50[59]->in[4] mux_2level_size50[59]->in[5] mux_2level_size50[59]->in[6] mux_2level_size50[59]->in[7] mux_2level_size50[59]->in[8] mux_2level_size50[59]->in[9] mux_2level_size50[59]->in[10] mux_2level_size50[59]->in[11] mux_2level_size50[59]->in[12] mux_2level_size50[59]->in[13] mux_2level_size50[59]->in[14] mux_2level_size50[59]->in[15] mux_2level_size50[59]->in[16] mux_2level_size50[59]->in[17] mux_2level_size50[59]->in[18] mux_2level_size50[59]->in[19] mux_2level_size50[59]->in[20] mux_2level_size50[59]->in[21] mux_2level_size50[59]->in[22] mux_2level_size50[59]->in[23] mux_2level_size50[59]->in[24] mux_2level_size50[59]->in[25] mux_2level_size50[59]->in[26] mux_2level_size50[59]->in[27] mux_2level_size50[59]->in[28] mux_2level_size50[59]->in[29] mux_2level_size50[59]->in[30] mux_2level_size50[59]->in[31] mux_2level_size50[59]->in[32] mux_2level_size50[59]->in[33] mux_2level_size50[59]->in[34] mux_2level_size50[59]->in[35] mux_2level_size50[59]->in[36] mux_2level_size50[59]->in[37] mux_2level_size50[59]->in[38] mux_2level_size50[59]->in[39] mux_2level_size50[59]->in[40] mux_2level_size50[59]->in[41] mux_2level_size50[59]->in[42] mux_2level_size50[59]->in[43] mux_2level_size50[59]->in[44] mux_2level_size50[59]->in[45] mux_2level_size50[59]->in[46] mux_2level_size50[59]->in[47] mux_2level_size50[59]->in[48] mux_2level_size50[59]->in[49] mux_2level_size50[59]->out sram[944]->outb sram[944]->out sram[945]->out sram[945]->outb sram[946]->out sram[946]->outb sram[947]->out sram[947]->outb sram[948]->out sram[948]->outb sram[949]->out sram[949]->outb sram[950]->out sram[950]->outb sram[951]->out sram[951]->outb sram[952]->outb sram[952]->out sram[953]->out sram[953]->outb sram[954]->out sram[954]->outb sram[955]->out sram[955]->outb sram[956]->out sram[956]->outb sram[957]->out sram[957]->outb sram[958]->out sram[958]->outb sram[959]->out sram[959]->outb gvdd_mux_2level_size50[59] 0 mux_2level_size50
***** SRAM bits for MUX[59], level=2, select_path_id=0. *****
*****1000000010000000*****
Xsram[944] sram->in sram[944]->out sram[944]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[944]->out) 0
.nodeset V(sram[944]->outb) vsp
Xsram[945] sram->in sram[945]->out sram[945]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[945]->out) 0
.nodeset V(sram[945]->outb) vsp
Xsram[946] sram->in sram[946]->out sram[946]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[946]->out) 0
.nodeset V(sram[946]->outb) vsp
Xsram[947] sram->in sram[947]->out sram[947]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[947]->out) 0
.nodeset V(sram[947]->outb) vsp
Xsram[948] sram->in sram[948]->out sram[948]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[948]->out) 0
.nodeset V(sram[948]->outb) vsp
Xsram[949] sram->in sram[949]->out sram[949]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[949]->out) 0
.nodeset V(sram[949]->outb) vsp
Xsram[950] sram->in sram[950]->out sram[950]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[950]->out) 0
.nodeset V(sram[950]->outb) vsp
Xsram[951] sram->in sram[951]->out sram[951]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[951]->out) 0
.nodeset V(sram[951]->outb) vsp
Xsram[952] sram->in sram[952]->out sram[952]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[952]->out) 0
.nodeset V(sram[952]->outb) vsp
Xsram[953] sram->in sram[953]->out sram[953]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[953]->out) 0
.nodeset V(sram[953]->outb) vsp
Xsram[954] sram->in sram[954]->out sram[954]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[954]->out) 0
.nodeset V(sram[954]->outb) vsp
Xsram[955] sram->in sram[955]->out sram[955]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[955]->out) 0
.nodeset V(sram[955]->outb) vsp
Xsram[956] sram->in sram[956]->out sram[956]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[956]->out) 0
.nodeset V(sram[956]->outb) vsp
Xsram[957] sram->in sram[957]->out sram[957]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[957]->out) 0
.nodeset V(sram[957]->outb) vsp
Xsram[958] sram->in sram[958]->out sram[958]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[958]->out) 0
.nodeset V(sram[958]->outb) vsp
Xsram[959] sram->in sram[959]->out sram[959]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[959]->out) 0
.nodeset V(sram[959]->outb) vsp
***** Signal mux_2level_size50[59]->in[0] density = 0, probability=0.*****
Vmux_2level_size50[59]->in[0] mux_2level_size50[59]->in[0] 0
+  0
***** Signal mux_2level_size50[59]->in[1] density = 0, probability=0.*****
Vmux_2level_size50[59]->in[1] mux_2level_size50[59]->in[1] 0
+  0
***** Signal mux_2level_size50[59]->in[2] density = 0, probability=0.*****
Vmux_2level_size50[59]->in[2] mux_2level_size50[59]->in[2] 0
+  0
***** Signal mux_2level_size50[59]->in[3] density = 0, probability=0.*****
Vmux_2level_size50[59]->in[3] mux_2level_size50[59]->in[3] 0
+  0
***** Signal mux_2level_size50[59]->in[4] density = 0, probability=0.*****
Vmux_2level_size50[59]->in[4] mux_2level_size50[59]->in[4] 0
+  0
***** Signal mux_2level_size50[59]->in[5] density = 0, probability=0.*****
Vmux_2level_size50[59]->in[5] mux_2level_size50[59]->in[5] 0
+  0
***** Signal mux_2level_size50[59]->in[6] density = 0, probability=0.*****
Vmux_2level_size50[59]->in[6] mux_2level_size50[59]->in[6] 0
+  0
***** Signal mux_2level_size50[59]->in[7] density = 0, probability=0.*****
Vmux_2level_size50[59]->in[7] mux_2level_size50[59]->in[7] 0
+  0
***** Signal mux_2level_size50[59]->in[8] density = 0, probability=0.*****
Vmux_2level_size50[59]->in[8] mux_2level_size50[59]->in[8] 0
+  0
***** Signal mux_2level_size50[59]->in[9] density = 0, probability=0.*****
Vmux_2level_size50[59]->in[9] mux_2level_size50[59]->in[9] 0
+  0
***** Signal mux_2level_size50[59]->in[10] density = 0, probability=0.*****
Vmux_2level_size50[59]->in[10] mux_2level_size50[59]->in[10] 0
+  0
***** Signal mux_2level_size50[59]->in[11] density = 0, probability=0.*****
Vmux_2level_size50[59]->in[11] mux_2level_size50[59]->in[11] 0
+  0
***** Signal mux_2level_size50[59]->in[12] density = 0, probability=0.*****
Vmux_2level_size50[59]->in[12] mux_2level_size50[59]->in[12] 0
+  0
***** Signal mux_2level_size50[59]->in[13] density = 0, probability=0.*****
Vmux_2level_size50[59]->in[13] mux_2level_size50[59]->in[13] 0
+  0
***** Signal mux_2level_size50[59]->in[14] density = 0, probability=0.*****
Vmux_2level_size50[59]->in[14] mux_2level_size50[59]->in[14] 0
+  0
***** Signal mux_2level_size50[59]->in[15] density = 0, probability=0.*****
Vmux_2level_size50[59]->in[15] mux_2level_size50[59]->in[15] 0
+  0
***** Signal mux_2level_size50[59]->in[16] density = 0, probability=0.*****
Vmux_2level_size50[59]->in[16] mux_2level_size50[59]->in[16] 0
+  0
***** Signal mux_2level_size50[59]->in[17] density = 0, probability=0.*****
Vmux_2level_size50[59]->in[17] mux_2level_size50[59]->in[17] 0
+  0
***** Signal mux_2level_size50[59]->in[18] density = 0, probability=0.*****
Vmux_2level_size50[59]->in[18] mux_2level_size50[59]->in[18] 0
+  0
***** Signal mux_2level_size50[59]->in[19] density = 0, probability=0.*****
Vmux_2level_size50[59]->in[19] mux_2level_size50[59]->in[19] 0
+  0
***** Signal mux_2level_size50[59]->in[20] density = 0, probability=0.*****
Vmux_2level_size50[59]->in[20] mux_2level_size50[59]->in[20] 0
+  0
***** Signal mux_2level_size50[59]->in[21] density = 0, probability=0.*****
Vmux_2level_size50[59]->in[21] mux_2level_size50[59]->in[21] 0
+  0
***** Signal mux_2level_size50[59]->in[22] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[59]->in[22] mux_2level_size50[59]->in[22] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[59]->in[23] density = 0, probability=0.*****
Vmux_2level_size50[59]->in[23] mux_2level_size50[59]->in[23] 0
+  0
***** Signal mux_2level_size50[59]->in[24] density = 0, probability=0.*****
Vmux_2level_size50[59]->in[24] mux_2level_size50[59]->in[24] 0
+  0
***** Signal mux_2level_size50[59]->in[25] density = 0, probability=0.*****
Vmux_2level_size50[59]->in[25] mux_2level_size50[59]->in[25] 0
+  0
***** Signal mux_2level_size50[59]->in[26] density = 0, probability=0.*****
Vmux_2level_size50[59]->in[26] mux_2level_size50[59]->in[26] 0
+  0
***** Signal mux_2level_size50[59]->in[27] density = 0, probability=0.*****
Vmux_2level_size50[59]->in[27] mux_2level_size50[59]->in[27] 0
+  0
***** Signal mux_2level_size50[59]->in[28] density = 0, probability=0.*****
Vmux_2level_size50[59]->in[28] mux_2level_size50[59]->in[28] 0
+  0
***** Signal mux_2level_size50[59]->in[29] density = 0, probability=0.*****
Vmux_2level_size50[59]->in[29] mux_2level_size50[59]->in[29] 0
+  0
***** Signal mux_2level_size50[59]->in[30] density = 0, probability=0.*****
Vmux_2level_size50[59]->in[30] mux_2level_size50[59]->in[30] 0
+  0
***** Signal mux_2level_size50[59]->in[31] density = 0, probability=0.*****
Vmux_2level_size50[59]->in[31] mux_2level_size50[59]->in[31] 0
+  0
***** Signal mux_2level_size50[59]->in[32] density = 0, probability=0.*****
Vmux_2level_size50[59]->in[32] mux_2level_size50[59]->in[32] 0
+  0
***** Signal mux_2level_size50[59]->in[33] density = 0, probability=0.*****
Vmux_2level_size50[59]->in[33] mux_2level_size50[59]->in[33] 0
+  0
***** Signal mux_2level_size50[59]->in[34] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[59]->in[34] mux_2level_size50[59]->in[34] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[59]->in[35] density = 0, probability=0.*****
Vmux_2level_size50[59]->in[35] mux_2level_size50[59]->in[35] 0
+  0
***** Signal mux_2level_size50[59]->in[36] density = 0, probability=0.*****
Vmux_2level_size50[59]->in[36] mux_2level_size50[59]->in[36] 0
+  0
***** Signal mux_2level_size50[59]->in[37] density = 0, probability=0.*****
Vmux_2level_size50[59]->in[37] mux_2level_size50[59]->in[37] 0
+  0
***** Signal mux_2level_size50[59]->in[38] density = 0.2026, probability=0.5018.*****
Vmux_2level_size50[59]->in[38] mux_2level_size50[59]->in[38] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_2level_size50[59]->in[39] density = 0, probability=0.*****
Vmux_2level_size50[59]->in[39] mux_2level_size50[59]->in[39] 0
+  0
***** Signal mux_2level_size50[59]->in[40] density = 0, probability=0.*****
Vmux_2level_size50[59]->in[40] mux_2level_size50[59]->in[40] 0
+  0
***** Signal mux_2level_size50[59]->in[41] density = 0, probability=0.*****
Vmux_2level_size50[59]->in[41] mux_2level_size50[59]->in[41] 0
+  0
***** Signal mux_2level_size50[59]->in[42] density = 0, probability=0.*****
Vmux_2level_size50[59]->in[42] mux_2level_size50[59]->in[42] 0
+  0
***** Signal mux_2level_size50[59]->in[43] density = 0, probability=0.*****
Vmux_2level_size50[59]->in[43] mux_2level_size50[59]->in[43] 0
+  0
***** Signal mux_2level_size50[59]->in[44] density = 0, probability=0.*****
Vmux_2level_size50[59]->in[44] mux_2level_size50[59]->in[44] 0
+  0
***** Signal mux_2level_size50[59]->in[45] density = 0, probability=0.*****
Vmux_2level_size50[59]->in[45] mux_2level_size50[59]->in[45] 0
+  0
***** Signal mux_2level_size50[59]->in[46] density = 0, probability=0.*****
Vmux_2level_size50[59]->in[46] mux_2level_size50[59]->in[46] 0
+  0
***** Signal mux_2level_size50[59]->in[47] density = 0, probability=0.*****
Vmux_2level_size50[59]->in[47] mux_2level_size50[59]->in[47] 0
+  0
***** Signal mux_2level_size50[59]->in[48] density = 0, probability=0.*****
Vmux_2level_size50[59]->in[48] mux_2level_size50[59]->in[48] 0
+  0
***** Signal mux_2level_size50[59]->in[49] density = 0.2026, probability=0.4982.*****
Vmux_2level_size50[59]->in[49] mux_2level_size50[59]->in[49] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.4982*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
Vgvdd_mux_2level_size50[59] gvdd_mux_2level_size50[59] 0 vsp
***** Measurements *****
***** Rise delay *****
.meas tran delay_rise_grid[1][1]_clb[0]_mode[clb]_fle[9]_mode[n1_lut6]_in[5]_crossbar trig v(mux_2level_size50[59]->in[0]) val='input_thres_pct_rise*vsp' rise=1 td='clock_period'
+          targ v(mux_2level_size50[59]->out) val='output_thres_pct_rise*vsp' rise=1 td='clock_period'
***** Fall delay *****
.meas tran delay_fall_grid[1][1]_clb[0]_mode[clb]_fle[9]_mode[n1_lut6]_in[5]_crossbar trig v(mux_2level_size50[59]->in[0]) val='input_thres_pct_fall*vsp' fall=1 td='clock_period'
+          targ v(mux_2level_size50[59]->out) val='output_thres_pct_fall*vsp' fall=1 td='clock_period'
***** Rise timing period *****
.meas start_rise_grid[1][1]_clb[0]_mode[clb]_fle[9]_mode[n1_lut6]_in[5]_crossbar when v(mux_2level_size50[59]->in[0])='slew_lower_thres_pct_rise*vsp' rise=1 td='clock_period'
.meas tran switch_rise_grid[1][1]_clb[0]_mode[clb]_fle[9]_mode[n1_lut6]_in[5]_crossbar trig v(mux_2level_size50[59]->in[0]) val='slew_lower_thres_pct_rise*vsp' rise=1 td='clock_period'
+          targ v(mux_2level_size50[59]->out) val='slew_upper_thres_pct_rise*vsp' rise=1 td='clock_period'
***** Fall timing period *****
.meas start_fall_grid[1][1]_clb[0]_mode[clb]_fle[9]_mode[n1_lut6]_in[5]_crossbar when v(mux_2level_size50[59]->in[0])='slew_lower_thres_pct_fall*vsp' fall=1 td='clock_period'
.meas tran switch_fall_grid[1][1]_clb[0]_mode[clb]_fle[9]_mode[n1_lut6]_in[5]_crossbar trig v(mux_2level_size50[59]->in[0]) val='slew_lower_thres_pct_fall*vsp' fall=1 td='clock_period'
+          targ v(mux_2level_size50[59]->out) val='slew_upper_thres_pct_fall*vsp' fall=1 td='clock_period'
***** Leakage Power Measurement *****
.meas tran mux_2level_size50[59]_leakage_power avg p(Vgvdd_mux_2level_size50[59]) from=0 to='clock_period'
.meas tran leakage_grid[1][1]_clb[0]_mode[clb]_fle[9]_mode[n1_lut6]_in[5]_crossbar param='mux_2level_size50[59]_leakage_power'
***** Dynamic Power Measurement *****
.meas tran mux_2level_size50[59]_dynamic_power avg p(Vgvdd_mux_2level_size50[59]) from='clock_period' to='6*clock_period'
.meas tran mux_2level_size50[59]_energy_per_cycle param='mux_2level_size50[59]_dynamic_power*clock_period'
.meas tran dynamic_power_grid[1][1]_clb[0]_mode[clb]_fle[9]_mode[n1_lut6]_in[5]_crossbar  param='mux_2level_size50[59]_dynamic_power'
.meas tran energy_per_cycle_grid[1][1]_clb[0]_mode[clb]_fle[9]_mode[n1_lut6]_in[5]_crossbar  param='dynamic_power_grid[1][1]_clb[0]_mode[clb]_fle[9]_mode[n1_lut6]_in[5]_crossbar*clock_period'
.meas tran dynamic_rise_grid[1][1]_clb[0]_mode[clb]_fle[9]_mode[n1_lut6]_in[5]_crossbar avg p(Vgvdd_mux_2level_size50[59]) from='start_rise_grid[1][1]_clb[0]_mode[clb]_fle[9]_mode[n1_lut6]_in[5]_crossbar' to='start_rise_grid[1][1]_clb[0]_mode[clb]_fle[9]_mode[n1_lut6]_in[5]_crossbar+switch_rise_grid[1][1]_clb[0]_mode[clb]_fle[9]_mode[n1_lut6]_in[5]_crossbar'
.meas tran dynamic_fall_grid[1][1]_clb[0]_mode[clb]_fle[9]_mode[n1_lut6]_in[5]_crossbar avg p(Vgvdd_mux_2level_size50[59]) from='start_fall_grid[1][1]_clb[0]_mode[clb]_fle[9]_mode[n1_lut6]_in[5]_crossbar' to='start_fall_grid[1][1]_clb[0]_mode[clb]_fle[9]_mode[n1_lut6]_in[5]_crossbar+switch_fall_grid[1][1]_clb[0]_mode[clb]_fle[9]_mode[n1_lut6]_in[5]_crossbar'
.meas tran sum_leakage_power_mux[0to59]
+          param='sum_leakage_power_mux[0to58]+leakage_grid[1][1]_clb[0]_mode[clb]_fle[9]_mode[n1_lut6]_in[5]_crossbar'
.meas tran sum_energy_per_cycle_mux[0to59]
+          param='sum_energy_per_cycle_mux[0to58]+energy_per_cycle_grid[1][1]_clb[0]_mode[clb]_fle[9]_mode[n1_lut6]_in[5]_crossbar'
Xload_inv[59]_no0 mux_2level_size50[59]->out mux_2level_size50[59]->out_out[0] gvdd_load 0 inv size=5
.meas tran sum_leakage_power_pb_mux[0to59]
+          param='sum_leakage_power_pb_mux[0to58]+leakage_grid[1][1]_clb[0]_mode[clb]_fle[9]_mode[n1_lut6]_in[5]_crossbar'
.meas tran sum_energy_per_cycle_pb_mux[0to59]
+          param='sum_energy_per_cycle_pb_mux[0to58]+energy_per_cycle_grid[1][1]_clb[0]_mode[clb]_fle[9]_mode[n1_lut6]_in[5]_crossbar'
Xmux_1level_tapbuf_size2[60] mux_1level_tapbuf_size2[60]->in[0] mux_1level_tapbuf_size2[60]->in[1] mux_1level_tapbuf_size2[60]->out sram[960]->outb sram[960]->out gvdd_mux_1level_tapbuf_size2[60] 0 mux_1level_tapbuf_size2
***** SRAM bits for MUX[60], level=1, select_path_id=0. *****
*****1*****
Xsram[960] sram->in sram[960]->out sram[960]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[960]->out) 0
.nodeset V(sram[960]->outb) vsp
***** Signal mux_1level_tapbuf_size2[60]->in[0] density = 0.2026, probability=0.5018.*****
Vmux_1level_tapbuf_size2[60]->in[0] mux_1level_tapbuf_size2[60]->in[0] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_1level_tapbuf_size2[60]->in[1] density = 0.2026, probability=0.5018.*****
Vmux_1level_tapbuf_size2[60]->in[1] mux_1level_tapbuf_size2[60]->in[1] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
Vgvdd_mux_1level_tapbuf_size2[60] gvdd_mux_1level_tapbuf_size2[60] 0 vsp
***** Measurements *****
***** Rise delay *****
.meas tran delay_rise_idle_mux2[60]_out[0]_mux1 trig v(mux_1level_tapbuf_size2[60]->in[0]) val='input_thres_pct_rise*vsp' rise=1 td='clock_period'
+          targ v(mux_1level_tapbuf_size2[60]->out) val='output_thres_pct_rise*vsp' rise=1 td='clock_period'
***** Fall delay *****
.meas tran delay_fall_idle_mux2[60]_out[0]_mux1 trig v(mux_1level_tapbuf_size2[60]->in[0]) val='input_thres_pct_fall*vsp' fall=1 td='clock_period'
+          targ v(mux_1level_tapbuf_size2[60]->out) val='output_thres_pct_fall*vsp' fall=1 td='clock_period'
***** Rise timing period *****
.meas start_rise_idle_mux2[60]_out[0]_mux1 when v(mux_1level_tapbuf_size2[60]->in[0])='slew_lower_thres_pct_rise*vsp' rise=1 td='clock_period'
.meas tran switch_rise_idle_mux2[60]_out[0]_mux1 trig v(mux_1level_tapbuf_size2[60]->in[0]) val='slew_lower_thres_pct_rise*vsp' rise=1 td='clock_period'
+          targ v(mux_1level_tapbuf_size2[60]->out) val='slew_upper_thres_pct_rise*vsp' rise=1 td='clock_period'
***** Fall timing period *****
.meas start_fall_idle_mux2[60]_out[0]_mux1 when v(mux_1level_tapbuf_size2[60]->in[0])='slew_lower_thres_pct_fall*vsp' fall=1 td='clock_period'
.meas tran switch_fall_idle_mux2[60]_out[0]_mux1 trig v(mux_1level_tapbuf_size2[60]->in[0]) val='slew_lower_thres_pct_fall*vsp' fall=1 td='clock_period'
+          targ v(mux_1level_tapbuf_size2[60]->out) val='slew_upper_thres_pct_fall*vsp' fall=1 td='clock_period'
***** Leakage Power Measurement *****
.meas tran mux_1level_tapbuf_size2[60]_leakage_power avg p(Vgvdd_mux_1level_tapbuf_size2[60]) from=0 to='clock_period'
.meas tran leakage_idle_mux2[60]_out[0]_mux1 param='mux_1level_tapbuf_size2[60]_leakage_power'
***** Dynamic Power Measurement *****
.meas tran mux_1level_tapbuf_size2[60]_dynamic_power avg p(Vgvdd_mux_1level_tapbuf_size2[60]) from='clock_period' to='6*clock_period'
.meas tran mux_1level_tapbuf_size2[60]_energy_per_cycle param='mux_1level_tapbuf_size2[60]_dynamic_power*clock_period'
.meas tran dynamic_power_idle_mux2[60]_out[0]_mux1  param='mux_1level_tapbuf_size2[60]_dynamic_power'
.meas tran energy_per_cycle_idle_mux2[60]_out[0]_mux1  param='dynamic_power_idle_mux2[60]_out[0]_mux1*clock_period'
.meas tran dynamic_rise_idle_mux2[60]_out[0]_mux1 avg p(Vgvdd_mux_1level_tapbuf_size2[60]) from='start_rise_idle_mux2[60]_out[0]_mux1' to='start_rise_idle_mux2[60]_out[0]_mux1+switch_rise_idle_mux2[60]_out[0]_mux1'
.meas tran dynamic_fall_idle_mux2[60]_out[0]_mux1 avg p(Vgvdd_mux_1level_tapbuf_size2[60]) from='start_fall_idle_mux2[60]_out[0]_mux1' to='start_fall_idle_mux2[60]_out[0]_mux1+switch_fall_idle_mux2[60]_out[0]_mux1'
.meas tran sum_leakage_power_mux[0to60]
+          param='sum_leakage_power_mux[0to59]+leakage_idle_mux2[60]_out[0]_mux1'
.meas tran sum_energy_per_cycle_mux[0to60]
+          param='sum_energy_per_cycle_mux[0to59]+energy_per_cycle_idle_mux2[60]_out[0]_mux1'
Xload_inv[60]_no0 mux_1level_tapbuf_size2[60]->out mux_1level_tapbuf_size2[60]->out_out[0] gvdd_load 0 inv size=1
Xload_inv[61]_no0 mux_1level_tapbuf_size2[60]->out mux_1level_tapbuf_size2[60]->out_out[1] gvdd_load 0 inv size=1
Xload_inv[62]_no0 mux_1level_tapbuf_size2[60]->out mux_1level_tapbuf_size2[60]->out_out[2] gvdd_load 0 inv size=1
Xload_inv[63]_no0 mux_1level_tapbuf_size2[60]->out mux_1level_tapbuf_size2[60]->out_out[3] gvdd_load 0 inv size=1
Xload_inv[64]_no0 mux_1level_tapbuf_size2[60]->out mux_1level_tapbuf_size2[60]->out_out[4] gvdd_load 0 inv size=1
Xload_inv[65]_no0 mux_1level_tapbuf_size2[60]->out mux_1level_tapbuf_size2[60]->out_out[5] gvdd_load 0 inv size=1
Xload_inv[66]_no0 mux_1level_tapbuf_size2[60]->out mux_1level_tapbuf_size2[60]->out_out[6] gvdd_load 0 inv size=1
Xload_inv[67]_no0 mux_1level_tapbuf_size2[60]->out mux_1level_tapbuf_size2[60]->out_out[7] gvdd_load 0 inv size=1
Xload_inv[68]_no0 mux_1level_tapbuf_size2[60]->out mux_1level_tapbuf_size2[60]->out_out[8] gvdd_load 0 inv size=1
Xload_inv[69]_no0 mux_1level_tapbuf_size2[60]->out mux_1level_tapbuf_size2[60]->out_out[9] gvdd_load 0 inv size=1
Xload_inv[70]_no0 mux_1level_tapbuf_size2[60]->out mux_1level_tapbuf_size2[60]->out_out[10] gvdd_load 0 inv size=1
Xload_inv[71]_no0 mux_1level_tapbuf_size2[60]->out mux_1level_tapbuf_size2[60]->out_out[11] gvdd_load 0 inv size=1
Xload_inv[72]_no0 mux_1level_tapbuf_size2[60]->out mux_1level_tapbuf_size2[60]->out_out[12] gvdd_load 0 inv size=1
Xload_inv[73]_no0 mux_1level_tapbuf_size2[60]->out mux_1level_tapbuf_size2[60]->out_out[13] gvdd_load 0 inv size=1
Xload_inv[74]_no0 mux_1level_tapbuf_size2[60]->out mux_1level_tapbuf_size2[60]->out_out[14] gvdd_load 0 inv size=1
Xload_inv[75]_no0 mux_1level_tapbuf_size2[60]->out mux_1level_tapbuf_size2[60]->out_out[15] gvdd_load 0 inv size=1
Xload_inv[76]_no0 mux_1level_tapbuf_size2[60]->out mux_1level_tapbuf_size2[60]->out_out[16] gvdd_load 0 inv size=1
Xload_inv[77]_no0 mux_1level_tapbuf_size2[60]->out mux_1level_tapbuf_size2[60]->out_out[17] gvdd_load 0 inv size=1
Xload_inv[78]_no0 mux_1level_tapbuf_size2[60]->out mux_1level_tapbuf_size2[60]->out_out[18] gvdd_load 0 inv size=1
Xload_inv[79]_no0 mux_1level_tapbuf_size2[60]->out mux_1level_tapbuf_size2[60]->out_out[19] gvdd_load 0 inv size=1
Xload_inv[80]_no0 mux_1level_tapbuf_size2[60]->out mux_1level_tapbuf_size2[60]->out_out[20] gvdd_load 0 inv size=1
Xload_inv[81]_no0 mux_1level_tapbuf_size2[60]->out mux_1level_tapbuf_size2[60]->out_out[21] gvdd_load 0 inv size=1
Xload_inv[82]_no0 mux_1level_tapbuf_size2[60]->out mux_1level_tapbuf_size2[60]->out_out[22] gvdd_load 0 inv size=1
Xload_inv[83]_no0 mux_1level_tapbuf_size2[60]->out mux_1level_tapbuf_size2[60]->out_out[23] gvdd_load 0 inv size=1
Xload_inv[84]_no0 mux_1level_tapbuf_size2[60]->out mux_1level_tapbuf_size2[60]->out_out[24] gvdd_load 0 inv size=1
Xload_inv[85]_no0 mux_1level_tapbuf_size2[60]->out mux_1level_tapbuf_size2[60]->out_out[25] gvdd_load 0 inv size=1
Xload_inv[86]_no0 mux_1level_tapbuf_size2[60]->out mux_1level_tapbuf_size2[60]->out_out[26] gvdd_load 0 inv size=1
Xload_inv[87]_no0 mux_1level_tapbuf_size2[60]->out mux_1level_tapbuf_size2[60]->out_out[27] gvdd_load 0 inv size=1
Xload_inv[88]_no0 mux_1level_tapbuf_size2[60]->out mux_1level_tapbuf_size2[60]->out_out[28] gvdd_load 0 inv size=1
Xload_inv[89]_no0 mux_1level_tapbuf_size2[60]->out mux_1level_tapbuf_size2[60]->out_out[29] gvdd_load 0 inv size=1
Xload_inv[90]_no0 mux_1level_tapbuf_size2[60]->out mux_1level_tapbuf_size2[60]->out_out[30] gvdd_load 0 inv size=1
Xload_inv[91]_no0 mux_1level_tapbuf_size2[60]->out mux_1level_tapbuf_size2[60]->out_out[31] gvdd_load 0 inv size=1
Xload_inv[92]_no0 mux_1level_tapbuf_size2[60]->out mux_1level_tapbuf_size2[60]->out_out[32] gvdd_load 0 inv size=1
Xload_inv[93]_no0 mux_1level_tapbuf_size2[60]->out mux_1level_tapbuf_size2[60]->out_out[33] gvdd_load 0 inv size=1
Xload_inv[94]_no0 mux_1level_tapbuf_size2[60]->out mux_1level_tapbuf_size2[60]->out_out[34] gvdd_load 0 inv size=1
Xload_inv[95]_no0 mux_1level_tapbuf_size2[60]->out mux_1level_tapbuf_size2[60]->out_out[35] gvdd_load 0 inv size=1
Xload_inv[96]_no0 mux_1level_tapbuf_size2[60]->out mux_1level_tapbuf_size2[60]->out_out[36] gvdd_load 0 inv size=1
Xload_inv[97]_no0 mux_1level_tapbuf_size2[60]->out mux_1level_tapbuf_size2[60]->out_out[37] gvdd_load 0 inv size=1
Xload_inv[98]_no0 mux_1level_tapbuf_size2[60]->out mux_1level_tapbuf_size2[60]->out_out[38] gvdd_load 0 inv size=1
Xload_inv[99]_no0 mux_1level_tapbuf_size2[60]->out mux_1level_tapbuf_size2[60]->out_out[39] gvdd_load 0 inv size=1
Xload_inv[100]_no0 mux_1level_tapbuf_size2[60]->out mux_1level_tapbuf_size2[60]->out_out[40] gvdd_load 0 inv size=1
Xload_inv[101]_no0 mux_1level_tapbuf_size2[60]->out mux_1level_tapbuf_size2[60]->out_out[41] gvdd_load 0 inv size=1
Xload_inv[102]_no0 mux_1level_tapbuf_size2[60]->out mux_1level_tapbuf_size2[60]->out_out[42] gvdd_load 0 inv size=1
Xload_inv[103]_no0 mux_1level_tapbuf_size2[60]->out mux_1level_tapbuf_size2[60]->out_out[43] gvdd_load 0 inv size=1
Xload_inv[104]_no0 mux_1level_tapbuf_size2[60]->out mux_1level_tapbuf_size2[60]->out_out[44] gvdd_load 0 inv size=1
Xload_inv[105]_no0 mux_1level_tapbuf_size2[60]->out mux_1level_tapbuf_size2[60]->out_out[45] gvdd_load 0 inv size=1
Xload_inv[106]_no0 mux_1level_tapbuf_size2[60]->out mux_1level_tapbuf_size2[60]->out_out[46] gvdd_load 0 inv size=1
Xload_inv[107]_no0 mux_1level_tapbuf_size2[60]->out mux_1level_tapbuf_size2[60]->out_out[47] gvdd_load 0 inv size=1
Xload_inv[108]_no0 mux_1level_tapbuf_size2[60]->out mux_1level_tapbuf_size2[60]->out_out[48] gvdd_load 0 inv size=1
Xload_inv[109]_no0 mux_1level_tapbuf_size2[60]->out mux_1level_tapbuf_size2[60]->out_out[49] gvdd_load 0 inv size=1
Xload_inv[110]_no0 mux_1level_tapbuf_size2[60]->out mux_1level_tapbuf_size2[60]->out_out[50] gvdd_load 0 inv size=1
Xload_inv[111]_no0 mux_1level_tapbuf_size2[60]->out mux_1level_tapbuf_size2[60]->out_out[51] gvdd_load 0 inv size=1
Xload_inv[112]_no0 mux_1level_tapbuf_size2[60]->out mux_1level_tapbuf_size2[60]->out_out[52] gvdd_load 0 inv size=1
Xload_inv[113]_no0 mux_1level_tapbuf_size2[60]->out mux_1level_tapbuf_size2[60]->out_out[53] gvdd_load 0 inv size=1
Xload_inv[114]_no0 mux_1level_tapbuf_size2[60]->out mux_1level_tapbuf_size2[60]->out_out[54] gvdd_load 0 inv size=1
Xload_inv[115]_no0 mux_1level_tapbuf_size2[60]->out mux_1level_tapbuf_size2[60]->out_out[55] gvdd_load 0 inv size=1
Xload_inv[116]_no0 mux_1level_tapbuf_size2[60]->out mux_1level_tapbuf_size2[60]->out_out[56] gvdd_load 0 inv size=1
Xload_inv[117]_no0 mux_1level_tapbuf_size2[60]->out mux_1level_tapbuf_size2[60]->out_out[57] gvdd_load 0 inv size=1
Xload_inv[118]_no0 mux_1level_tapbuf_size2[60]->out mux_1level_tapbuf_size2[60]->out_out[58] gvdd_load 0 inv size=1
Xload_inv[119]_no0 mux_1level_tapbuf_size2[60]->out mux_1level_tapbuf_size2[60]->out_out[59] gvdd_load 0 inv size=1
Xload_inv[120]_no0 mux_1level_tapbuf_size2[60]->out load_inv[120]_out gvdd_load 0 inv size=1
Xload_inv[121]_no0 mux_1level_tapbuf_size2[60]->out load_inv[121]_out gvdd_load 0 inv size=1
Xload_inv[122]_no0 mux_1level_tapbuf_size2[60]->out load_inv[122]_out gvdd_load 0 inv size=1
Xload_inv[123]_no0 mux_1level_tapbuf_size2[60]->out load_inv[123]_out gvdd_load 0 inv size=1
Xload_inv[124]_no0 mux_1level_tapbuf_size2[60]->out load_inv[124]_out gvdd_load 0 inv size=1
Xload_inv[125]_no0 mux_1level_tapbuf_size2[60]->out load_inv[125]_out gvdd_load 0 inv size=1
Xload_inv[126]_no0 mux_1level_tapbuf_size2[60]->out load_inv[126]_out gvdd_load 0 inv size=1
Xload_inv[127]_no0 mux_1level_tapbuf_size2[60]->out load_inv[127]_out gvdd_load 0 inv size=1
Xload_inv[128]_no0 mux_1level_tapbuf_size2[60]->out load_inv[128]_out gvdd_load 0 inv size=1
Xload_inv[129]_no0 mux_1level_tapbuf_size2[60]->out load_inv[129]_out gvdd_load 0 inv size=1
.meas tran sum_leakage_power_pb_mux[0to60]
+          param='sum_leakage_power_pb_mux[0to59]+leakage_idle_mux2[60]_out[0]_mux1'
.meas tran sum_energy_per_cycle_pb_mux[0to60]
+          param='sum_energy_per_cycle_pb_mux[0to59]+energy_per_cycle_idle_mux2[60]_out[0]_mux1'
Xmux_1level_tapbuf_size2[61] mux_1level_tapbuf_size2[61]->in[0] mux_1level_tapbuf_size2[61]->in[1] mux_1level_tapbuf_size2[61]->out sram[961]->outb sram[961]->out gvdd_mux_1level_tapbuf_size2[61] 0 mux_1level_tapbuf_size2
***** SRAM bits for MUX[61], level=1, select_path_id=0. *****
*****1*****
Xsram[961] sram->in sram[961]->out sram[961]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[961]->out) 0
.nodeset V(sram[961]->outb) vsp
***** Signal mux_1level_tapbuf_size2[61]->in[0] density = 0.2026, probability=0.5018.*****
Vmux_1level_tapbuf_size2[61]->in[0] mux_1level_tapbuf_size2[61]->in[0] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_1level_tapbuf_size2[61]->in[1] density = 0.2026, probability=0.5018.*****
Vmux_1level_tapbuf_size2[61]->in[1] mux_1level_tapbuf_size2[61]->in[1] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
Vgvdd_mux_1level_tapbuf_size2[61] gvdd_mux_1level_tapbuf_size2[61] 0 vsp
***** Measurements *****
***** Rise delay *****
.meas tran delay_rise_idle_mux2[61]_out[0]_mux1 trig v(mux_1level_tapbuf_size2[61]->in[0]) val='input_thres_pct_rise*vsp' rise=1 td='clock_period'
+          targ v(mux_1level_tapbuf_size2[61]->out) val='output_thres_pct_rise*vsp' rise=1 td='clock_period'
***** Fall delay *****
.meas tran delay_fall_idle_mux2[61]_out[0]_mux1 trig v(mux_1level_tapbuf_size2[61]->in[0]) val='input_thres_pct_fall*vsp' fall=1 td='clock_period'
+          targ v(mux_1level_tapbuf_size2[61]->out) val='output_thres_pct_fall*vsp' fall=1 td='clock_period'
***** Rise timing period *****
.meas start_rise_idle_mux2[61]_out[0]_mux1 when v(mux_1level_tapbuf_size2[61]->in[0])='slew_lower_thres_pct_rise*vsp' rise=1 td='clock_period'
.meas tran switch_rise_idle_mux2[61]_out[0]_mux1 trig v(mux_1level_tapbuf_size2[61]->in[0]) val='slew_lower_thres_pct_rise*vsp' rise=1 td='clock_period'
+          targ v(mux_1level_tapbuf_size2[61]->out) val='slew_upper_thres_pct_rise*vsp' rise=1 td='clock_period'
***** Fall timing period *****
.meas start_fall_idle_mux2[61]_out[0]_mux1 when v(mux_1level_tapbuf_size2[61]->in[0])='slew_lower_thres_pct_fall*vsp' fall=1 td='clock_period'
.meas tran switch_fall_idle_mux2[61]_out[0]_mux1 trig v(mux_1level_tapbuf_size2[61]->in[0]) val='slew_lower_thres_pct_fall*vsp' fall=1 td='clock_period'
+          targ v(mux_1level_tapbuf_size2[61]->out) val='slew_upper_thres_pct_fall*vsp' fall=1 td='clock_period'
***** Leakage Power Measurement *****
.meas tran mux_1level_tapbuf_size2[61]_leakage_power avg p(Vgvdd_mux_1level_tapbuf_size2[61]) from=0 to='clock_period'
.meas tran leakage_idle_mux2[61]_out[0]_mux1 param='mux_1level_tapbuf_size2[61]_leakage_power'
***** Dynamic Power Measurement *****
.meas tran mux_1level_tapbuf_size2[61]_dynamic_power avg p(Vgvdd_mux_1level_tapbuf_size2[61]) from='clock_period' to='6*clock_period'
.meas tran mux_1level_tapbuf_size2[61]_energy_per_cycle param='mux_1level_tapbuf_size2[61]_dynamic_power*clock_period'
.meas tran dynamic_power_idle_mux2[61]_out[0]_mux1  param='mux_1level_tapbuf_size2[61]_dynamic_power'
.meas tran energy_per_cycle_idle_mux2[61]_out[0]_mux1  param='dynamic_power_idle_mux2[61]_out[0]_mux1*clock_period'
.meas tran dynamic_rise_idle_mux2[61]_out[0]_mux1 avg p(Vgvdd_mux_1level_tapbuf_size2[61]) from='start_rise_idle_mux2[61]_out[0]_mux1' to='start_rise_idle_mux2[61]_out[0]_mux1+switch_rise_idle_mux2[61]_out[0]_mux1'
.meas tran dynamic_fall_idle_mux2[61]_out[0]_mux1 avg p(Vgvdd_mux_1level_tapbuf_size2[61]) from='start_fall_idle_mux2[61]_out[0]_mux1' to='start_fall_idle_mux2[61]_out[0]_mux1+switch_fall_idle_mux2[61]_out[0]_mux1'
.meas tran sum_leakage_power_mux[0to61]
+          param='sum_leakage_power_mux[0to60]+leakage_idle_mux2[61]_out[0]_mux1'
.meas tran sum_energy_per_cycle_mux[0to61]
+          param='sum_energy_per_cycle_mux[0to60]+energy_per_cycle_idle_mux2[61]_out[0]_mux1'
Xload_inv[130]_no0 mux_1level_tapbuf_size2[61]->out mux_1level_tapbuf_size2[61]->out_out[0] gvdd_load 0 inv size=1
Xload_inv[131]_no0 mux_1level_tapbuf_size2[61]->out mux_1level_tapbuf_size2[61]->out_out[1] gvdd_load 0 inv size=1
Xload_inv[132]_no0 mux_1level_tapbuf_size2[61]->out mux_1level_tapbuf_size2[61]->out_out[2] gvdd_load 0 inv size=1
Xload_inv[133]_no0 mux_1level_tapbuf_size2[61]->out mux_1level_tapbuf_size2[61]->out_out[3] gvdd_load 0 inv size=1
Xload_inv[134]_no0 mux_1level_tapbuf_size2[61]->out mux_1level_tapbuf_size2[61]->out_out[4] gvdd_load 0 inv size=1
Xload_inv[135]_no0 mux_1level_tapbuf_size2[61]->out mux_1level_tapbuf_size2[61]->out_out[5] gvdd_load 0 inv size=1
Xload_inv[136]_no0 mux_1level_tapbuf_size2[61]->out mux_1level_tapbuf_size2[61]->out_out[6] gvdd_load 0 inv size=1
Xload_inv[137]_no0 mux_1level_tapbuf_size2[61]->out mux_1level_tapbuf_size2[61]->out_out[7] gvdd_load 0 inv size=1
Xload_inv[138]_no0 mux_1level_tapbuf_size2[61]->out mux_1level_tapbuf_size2[61]->out_out[8] gvdd_load 0 inv size=1
Xload_inv[139]_no0 mux_1level_tapbuf_size2[61]->out mux_1level_tapbuf_size2[61]->out_out[9] gvdd_load 0 inv size=1
Xload_inv[140]_no0 mux_1level_tapbuf_size2[61]->out mux_1level_tapbuf_size2[61]->out_out[10] gvdd_load 0 inv size=1
Xload_inv[141]_no0 mux_1level_tapbuf_size2[61]->out mux_1level_tapbuf_size2[61]->out_out[11] gvdd_load 0 inv size=1
Xload_inv[142]_no0 mux_1level_tapbuf_size2[61]->out mux_1level_tapbuf_size2[61]->out_out[12] gvdd_load 0 inv size=1
Xload_inv[143]_no0 mux_1level_tapbuf_size2[61]->out mux_1level_tapbuf_size2[61]->out_out[13] gvdd_load 0 inv size=1
Xload_inv[144]_no0 mux_1level_tapbuf_size2[61]->out mux_1level_tapbuf_size2[61]->out_out[14] gvdd_load 0 inv size=1
Xload_inv[145]_no0 mux_1level_tapbuf_size2[61]->out mux_1level_tapbuf_size2[61]->out_out[15] gvdd_load 0 inv size=1
Xload_inv[146]_no0 mux_1level_tapbuf_size2[61]->out mux_1level_tapbuf_size2[61]->out_out[16] gvdd_load 0 inv size=1
Xload_inv[147]_no0 mux_1level_tapbuf_size2[61]->out mux_1level_tapbuf_size2[61]->out_out[17] gvdd_load 0 inv size=1
Xload_inv[148]_no0 mux_1level_tapbuf_size2[61]->out mux_1level_tapbuf_size2[61]->out_out[18] gvdd_load 0 inv size=1
Xload_inv[149]_no0 mux_1level_tapbuf_size2[61]->out mux_1level_tapbuf_size2[61]->out_out[19] gvdd_load 0 inv size=1
Xload_inv[150]_no0 mux_1level_tapbuf_size2[61]->out mux_1level_tapbuf_size2[61]->out_out[20] gvdd_load 0 inv size=1
Xload_inv[151]_no0 mux_1level_tapbuf_size2[61]->out mux_1level_tapbuf_size2[61]->out_out[21] gvdd_load 0 inv size=1
Xload_inv[152]_no0 mux_1level_tapbuf_size2[61]->out mux_1level_tapbuf_size2[61]->out_out[22] gvdd_load 0 inv size=1
Xload_inv[153]_no0 mux_1level_tapbuf_size2[61]->out mux_1level_tapbuf_size2[61]->out_out[23] gvdd_load 0 inv size=1
Xload_inv[154]_no0 mux_1level_tapbuf_size2[61]->out mux_1level_tapbuf_size2[61]->out_out[24] gvdd_load 0 inv size=1
Xload_inv[155]_no0 mux_1level_tapbuf_size2[61]->out mux_1level_tapbuf_size2[61]->out_out[25] gvdd_load 0 inv size=1
Xload_inv[156]_no0 mux_1level_tapbuf_size2[61]->out mux_1level_tapbuf_size2[61]->out_out[26] gvdd_load 0 inv size=1
Xload_inv[157]_no0 mux_1level_tapbuf_size2[61]->out mux_1level_tapbuf_size2[61]->out_out[27] gvdd_load 0 inv size=1
Xload_inv[158]_no0 mux_1level_tapbuf_size2[61]->out mux_1level_tapbuf_size2[61]->out_out[28] gvdd_load 0 inv size=1
Xload_inv[159]_no0 mux_1level_tapbuf_size2[61]->out mux_1level_tapbuf_size2[61]->out_out[29] gvdd_load 0 inv size=1
Xload_inv[160]_no0 mux_1level_tapbuf_size2[61]->out mux_1level_tapbuf_size2[61]->out_out[30] gvdd_load 0 inv size=1
Xload_inv[161]_no0 mux_1level_tapbuf_size2[61]->out mux_1level_tapbuf_size2[61]->out_out[31] gvdd_load 0 inv size=1
Xload_inv[162]_no0 mux_1level_tapbuf_size2[61]->out mux_1level_tapbuf_size2[61]->out_out[32] gvdd_load 0 inv size=1
Xload_inv[163]_no0 mux_1level_tapbuf_size2[61]->out mux_1level_tapbuf_size2[61]->out_out[33] gvdd_load 0 inv size=1
Xload_inv[164]_no0 mux_1level_tapbuf_size2[61]->out mux_1level_tapbuf_size2[61]->out_out[34] gvdd_load 0 inv size=1
Xload_inv[165]_no0 mux_1level_tapbuf_size2[61]->out mux_1level_tapbuf_size2[61]->out_out[35] gvdd_load 0 inv size=1
Xload_inv[166]_no0 mux_1level_tapbuf_size2[61]->out mux_1level_tapbuf_size2[61]->out_out[36] gvdd_load 0 inv size=1
Xload_inv[167]_no0 mux_1level_tapbuf_size2[61]->out mux_1level_tapbuf_size2[61]->out_out[37] gvdd_load 0 inv size=1
Xload_inv[168]_no0 mux_1level_tapbuf_size2[61]->out mux_1level_tapbuf_size2[61]->out_out[38] gvdd_load 0 inv size=1
Xload_inv[169]_no0 mux_1level_tapbuf_size2[61]->out mux_1level_tapbuf_size2[61]->out_out[39] gvdd_load 0 inv size=1
Xload_inv[170]_no0 mux_1level_tapbuf_size2[61]->out mux_1level_tapbuf_size2[61]->out_out[40] gvdd_load 0 inv size=1
Xload_inv[171]_no0 mux_1level_tapbuf_size2[61]->out mux_1level_tapbuf_size2[61]->out_out[41] gvdd_load 0 inv size=1
Xload_inv[172]_no0 mux_1level_tapbuf_size2[61]->out mux_1level_tapbuf_size2[61]->out_out[42] gvdd_load 0 inv size=1
Xload_inv[173]_no0 mux_1level_tapbuf_size2[61]->out mux_1level_tapbuf_size2[61]->out_out[43] gvdd_load 0 inv size=1
Xload_inv[174]_no0 mux_1level_tapbuf_size2[61]->out mux_1level_tapbuf_size2[61]->out_out[44] gvdd_load 0 inv size=1
Xload_inv[175]_no0 mux_1level_tapbuf_size2[61]->out mux_1level_tapbuf_size2[61]->out_out[45] gvdd_load 0 inv size=1
Xload_inv[176]_no0 mux_1level_tapbuf_size2[61]->out mux_1level_tapbuf_size2[61]->out_out[46] gvdd_load 0 inv size=1
Xload_inv[177]_no0 mux_1level_tapbuf_size2[61]->out mux_1level_tapbuf_size2[61]->out_out[47] gvdd_load 0 inv size=1
Xload_inv[178]_no0 mux_1level_tapbuf_size2[61]->out mux_1level_tapbuf_size2[61]->out_out[48] gvdd_load 0 inv size=1
Xload_inv[179]_no0 mux_1level_tapbuf_size2[61]->out mux_1level_tapbuf_size2[61]->out_out[49] gvdd_load 0 inv size=1
Xload_inv[180]_no0 mux_1level_tapbuf_size2[61]->out mux_1level_tapbuf_size2[61]->out_out[50] gvdd_load 0 inv size=1
Xload_inv[181]_no0 mux_1level_tapbuf_size2[61]->out mux_1level_tapbuf_size2[61]->out_out[51] gvdd_load 0 inv size=1
Xload_inv[182]_no0 mux_1level_tapbuf_size2[61]->out mux_1level_tapbuf_size2[61]->out_out[52] gvdd_load 0 inv size=1
Xload_inv[183]_no0 mux_1level_tapbuf_size2[61]->out mux_1level_tapbuf_size2[61]->out_out[53] gvdd_load 0 inv size=1
Xload_inv[184]_no0 mux_1level_tapbuf_size2[61]->out mux_1level_tapbuf_size2[61]->out_out[54] gvdd_load 0 inv size=1
Xload_inv[185]_no0 mux_1level_tapbuf_size2[61]->out mux_1level_tapbuf_size2[61]->out_out[55] gvdd_load 0 inv size=1
Xload_inv[186]_no0 mux_1level_tapbuf_size2[61]->out mux_1level_tapbuf_size2[61]->out_out[56] gvdd_load 0 inv size=1
Xload_inv[187]_no0 mux_1level_tapbuf_size2[61]->out mux_1level_tapbuf_size2[61]->out_out[57] gvdd_load 0 inv size=1
Xload_inv[188]_no0 mux_1level_tapbuf_size2[61]->out mux_1level_tapbuf_size2[61]->out_out[58] gvdd_load 0 inv size=1
Xload_inv[189]_no0 mux_1level_tapbuf_size2[61]->out mux_1level_tapbuf_size2[61]->out_out[59] gvdd_load 0 inv size=1
Xload_inv[190]_no0 mux_1level_tapbuf_size2[61]->out load_inv[190]_out gvdd_load 0 inv size=1
Xload_inv[191]_no0 mux_1level_tapbuf_size2[61]->out load_inv[191]_out gvdd_load 0 inv size=1
Xload_inv[192]_no0 mux_1level_tapbuf_size2[61]->out load_inv[192]_out gvdd_load 0 inv size=1
Xload_inv[193]_no0 mux_1level_tapbuf_size2[61]->out load_inv[193]_out gvdd_load 0 inv size=1
Xload_inv[194]_no0 mux_1level_tapbuf_size2[61]->out load_inv[194]_out gvdd_load 0 inv size=1
Xload_inv[195]_no0 mux_1level_tapbuf_size2[61]->out load_inv[195]_out gvdd_load 0 inv size=1
Xload_inv[196]_no0 mux_1level_tapbuf_size2[61]->out load_inv[196]_out gvdd_load 0 inv size=1
Xload_inv[197]_no0 mux_1level_tapbuf_size2[61]->out load_inv[197]_out gvdd_load 0 inv size=1
Xload_inv[198]_no0 mux_1level_tapbuf_size2[61]->out load_inv[198]_out gvdd_load 0 inv size=1
Xload_inv[199]_no0 mux_1level_tapbuf_size2[61]->out load_inv[199]_out gvdd_load 0 inv size=1
.meas tran sum_leakage_power_pb_mux[0to61]
+          param='sum_leakage_power_pb_mux[0to60]+leakage_idle_mux2[61]_out[0]_mux1'
.meas tran sum_energy_per_cycle_pb_mux[0to61]
+          param='sum_energy_per_cycle_pb_mux[0to60]+energy_per_cycle_idle_mux2[61]_out[0]_mux1'
Xmux_1level_tapbuf_size2[62] mux_1level_tapbuf_size2[62]->in[0] mux_1level_tapbuf_size2[62]->in[1] mux_1level_tapbuf_size2[62]->out sram[962]->outb sram[962]->out gvdd_mux_1level_tapbuf_size2[62] 0 mux_1level_tapbuf_size2
***** SRAM bits for MUX[62], level=1, select_path_id=0. *****
*****1*****
Xsram[962] sram->in sram[962]->out sram[962]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[962]->out) 0
.nodeset V(sram[962]->outb) vsp
***** Signal mux_1level_tapbuf_size2[62]->in[0] density = 0.2026, probability=0.5018.*****
Vmux_1level_tapbuf_size2[62]->in[0] mux_1level_tapbuf_size2[62]->in[0] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_1level_tapbuf_size2[62]->in[1] density = 0.2026, probability=0.5018.*****
Vmux_1level_tapbuf_size2[62]->in[1] mux_1level_tapbuf_size2[62]->in[1] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
Vgvdd_mux_1level_tapbuf_size2[62] gvdd_mux_1level_tapbuf_size2[62] 0 vsp
***** Measurements *****
***** Rise delay *****
.meas tran delay_rise_idle_mux2[62]_out[0]_mux1 trig v(mux_1level_tapbuf_size2[62]->in[0]) val='input_thres_pct_rise*vsp' rise=1 td='clock_period'
+          targ v(mux_1level_tapbuf_size2[62]->out) val='output_thres_pct_rise*vsp' rise=1 td='clock_period'
***** Fall delay *****
.meas tran delay_fall_idle_mux2[62]_out[0]_mux1 trig v(mux_1level_tapbuf_size2[62]->in[0]) val='input_thres_pct_fall*vsp' fall=1 td='clock_period'
+          targ v(mux_1level_tapbuf_size2[62]->out) val='output_thres_pct_fall*vsp' fall=1 td='clock_period'
***** Rise timing period *****
.meas start_rise_idle_mux2[62]_out[0]_mux1 when v(mux_1level_tapbuf_size2[62]->in[0])='slew_lower_thres_pct_rise*vsp' rise=1 td='clock_period'
.meas tran switch_rise_idle_mux2[62]_out[0]_mux1 trig v(mux_1level_tapbuf_size2[62]->in[0]) val='slew_lower_thres_pct_rise*vsp' rise=1 td='clock_period'
+          targ v(mux_1level_tapbuf_size2[62]->out) val='slew_upper_thres_pct_rise*vsp' rise=1 td='clock_period'
***** Fall timing period *****
.meas start_fall_idle_mux2[62]_out[0]_mux1 when v(mux_1level_tapbuf_size2[62]->in[0])='slew_lower_thres_pct_fall*vsp' fall=1 td='clock_period'
.meas tran switch_fall_idle_mux2[62]_out[0]_mux1 trig v(mux_1level_tapbuf_size2[62]->in[0]) val='slew_lower_thres_pct_fall*vsp' fall=1 td='clock_period'
+          targ v(mux_1level_tapbuf_size2[62]->out) val='slew_upper_thres_pct_fall*vsp' fall=1 td='clock_period'
***** Leakage Power Measurement *****
.meas tran mux_1level_tapbuf_size2[62]_leakage_power avg p(Vgvdd_mux_1level_tapbuf_size2[62]) from=0 to='clock_period'
.meas tran leakage_idle_mux2[62]_out[0]_mux1 param='mux_1level_tapbuf_size2[62]_leakage_power'
***** Dynamic Power Measurement *****
.meas tran mux_1level_tapbuf_size2[62]_dynamic_power avg p(Vgvdd_mux_1level_tapbuf_size2[62]) from='clock_period' to='6*clock_period'
.meas tran mux_1level_tapbuf_size2[62]_energy_per_cycle param='mux_1level_tapbuf_size2[62]_dynamic_power*clock_period'
.meas tran dynamic_power_idle_mux2[62]_out[0]_mux1  param='mux_1level_tapbuf_size2[62]_dynamic_power'
.meas tran energy_per_cycle_idle_mux2[62]_out[0]_mux1  param='dynamic_power_idle_mux2[62]_out[0]_mux1*clock_period'
.meas tran dynamic_rise_idle_mux2[62]_out[0]_mux1 avg p(Vgvdd_mux_1level_tapbuf_size2[62]) from='start_rise_idle_mux2[62]_out[0]_mux1' to='start_rise_idle_mux2[62]_out[0]_mux1+switch_rise_idle_mux2[62]_out[0]_mux1'
.meas tran dynamic_fall_idle_mux2[62]_out[0]_mux1 avg p(Vgvdd_mux_1level_tapbuf_size2[62]) from='start_fall_idle_mux2[62]_out[0]_mux1' to='start_fall_idle_mux2[62]_out[0]_mux1+switch_fall_idle_mux2[62]_out[0]_mux1'
.meas tran sum_leakage_power_mux[0to62]
+          param='sum_leakage_power_mux[0to61]+leakage_idle_mux2[62]_out[0]_mux1'
.meas tran sum_energy_per_cycle_mux[0to62]
+          param='sum_energy_per_cycle_mux[0to61]+energy_per_cycle_idle_mux2[62]_out[0]_mux1'
Xload_inv[200]_no0 mux_1level_tapbuf_size2[62]->out mux_1level_tapbuf_size2[62]->out_out[0] gvdd_load 0 inv size=1
Xload_inv[201]_no0 mux_1level_tapbuf_size2[62]->out mux_1level_tapbuf_size2[62]->out_out[1] gvdd_load 0 inv size=1
Xload_inv[202]_no0 mux_1level_tapbuf_size2[62]->out mux_1level_tapbuf_size2[62]->out_out[2] gvdd_load 0 inv size=1
Xload_inv[203]_no0 mux_1level_tapbuf_size2[62]->out mux_1level_tapbuf_size2[62]->out_out[3] gvdd_load 0 inv size=1
Xload_inv[204]_no0 mux_1level_tapbuf_size2[62]->out mux_1level_tapbuf_size2[62]->out_out[4] gvdd_load 0 inv size=1
Xload_inv[205]_no0 mux_1level_tapbuf_size2[62]->out mux_1level_tapbuf_size2[62]->out_out[5] gvdd_load 0 inv size=1
Xload_inv[206]_no0 mux_1level_tapbuf_size2[62]->out mux_1level_tapbuf_size2[62]->out_out[6] gvdd_load 0 inv size=1
Xload_inv[207]_no0 mux_1level_tapbuf_size2[62]->out mux_1level_tapbuf_size2[62]->out_out[7] gvdd_load 0 inv size=1
Xload_inv[208]_no0 mux_1level_tapbuf_size2[62]->out mux_1level_tapbuf_size2[62]->out_out[8] gvdd_load 0 inv size=1
Xload_inv[209]_no0 mux_1level_tapbuf_size2[62]->out mux_1level_tapbuf_size2[62]->out_out[9] gvdd_load 0 inv size=1
Xload_inv[210]_no0 mux_1level_tapbuf_size2[62]->out mux_1level_tapbuf_size2[62]->out_out[10] gvdd_load 0 inv size=1
Xload_inv[211]_no0 mux_1level_tapbuf_size2[62]->out mux_1level_tapbuf_size2[62]->out_out[11] gvdd_load 0 inv size=1
Xload_inv[212]_no0 mux_1level_tapbuf_size2[62]->out mux_1level_tapbuf_size2[62]->out_out[12] gvdd_load 0 inv size=1
Xload_inv[213]_no0 mux_1level_tapbuf_size2[62]->out mux_1level_tapbuf_size2[62]->out_out[13] gvdd_load 0 inv size=1
Xload_inv[214]_no0 mux_1level_tapbuf_size2[62]->out mux_1level_tapbuf_size2[62]->out_out[14] gvdd_load 0 inv size=1
Xload_inv[215]_no0 mux_1level_tapbuf_size2[62]->out mux_1level_tapbuf_size2[62]->out_out[15] gvdd_load 0 inv size=1
Xload_inv[216]_no0 mux_1level_tapbuf_size2[62]->out mux_1level_tapbuf_size2[62]->out_out[16] gvdd_load 0 inv size=1
Xload_inv[217]_no0 mux_1level_tapbuf_size2[62]->out mux_1level_tapbuf_size2[62]->out_out[17] gvdd_load 0 inv size=1
Xload_inv[218]_no0 mux_1level_tapbuf_size2[62]->out mux_1level_tapbuf_size2[62]->out_out[18] gvdd_load 0 inv size=1
Xload_inv[219]_no0 mux_1level_tapbuf_size2[62]->out mux_1level_tapbuf_size2[62]->out_out[19] gvdd_load 0 inv size=1
Xload_inv[220]_no0 mux_1level_tapbuf_size2[62]->out mux_1level_tapbuf_size2[62]->out_out[20] gvdd_load 0 inv size=1
Xload_inv[221]_no0 mux_1level_tapbuf_size2[62]->out mux_1level_tapbuf_size2[62]->out_out[21] gvdd_load 0 inv size=1
Xload_inv[222]_no0 mux_1level_tapbuf_size2[62]->out mux_1level_tapbuf_size2[62]->out_out[22] gvdd_load 0 inv size=1
Xload_inv[223]_no0 mux_1level_tapbuf_size2[62]->out mux_1level_tapbuf_size2[62]->out_out[23] gvdd_load 0 inv size=1
Xload_inv[224]_no0 mux_1level_tapbuf_size2[62]->out mux_1level_tapbuf_size2[62]->out_out[24] gvdd_load 0 inv size=1
Xload_inv[225]_no0 mux_1level_tapbuf_size2[62]->out mux_1level_tapbuf_size2[62]->out_out[25] gvdd_load 0 inv size=1
Xload_inv[226]_no0 mux_1level_tapbuf_size2[62]->out mux_1level_tapbuf_size2[62]->out_out[26] gvdd_load 0 inv size=1
Xload_inv[227]_no0 mux_1level_tapbuf_size2[62]->out mux_1level_tapbuf_size2[62]->out_out[27] gvdd_load 0 inv size=1
Xload_inv[228]_no0 mux_1level_tapbuf_size2[62]->out mux_1level_tapbuf_size2[62]->out_out[28] gvdd_load 0 inv size=1
Xload_inv[229]_no0 mux_1level_tapbuf_size2[62]->out mux_1level_tapbuf_size2[62]->out_out[29] gvdd_load 0 inv size=1
Xload_inv[230]_no0 mux_1level_tapbuf_size2[62]->out mux_1level_tapbuf_size2[62]->out_out[30] gvdd_load 0 inv size=1
Xload_inv[231]_no0 mux_1level_tapbuf_size2[62]->out mux_1level_tapbuf_size2[62]->out_out[31] gvdd_load 0 inv size=1
Xload_inv[232]_no0 mux_1level_tapbuf_size2[62]->out mux_1level_tapbuf_size2[62]->out_out[32] gvdd_load 0 inv size=1
Xload_inv[233]_no0 mux_1level_tapbuf_size2[62]->out mux_1level_tapbuf_size2[62]->out_out[33] gvdd_load 0 inv size=1
Xload_inv[234]_no0 mux_1level_tapbuf_size2[62]->out mux_1level_tapbuf_size2[62]->out_out[34] gvdd_load 0 inv size=1
Xload_inv[235]_no0 mux_1level_tapbuf_size2[62]->out mux_1level_tapbuf_size2[62]->out_out[35] gvdd_load 0 inv size=1
Xload_inv[236]_no0 mux_1level_tapbuf_size2[62]->out mux_1level_tapbuf_size2[62]->out_out[36] gvdd_load 0 inv size=1
Xload_inv[237]_no0 mux_1level_tapbuf_size2[62]->out mux_1level_tapbuf_size2[62]->out_out[37] gvdd_load 0 inv size=1
Xload_inv[238]_no0 mux_1level_tapbuf_size2[62]->out mux_1level_tapbuf_size2[62]->out_out[38] gvdd_load 0 inv size=1
Xload_inv[239]_no0 mux_1level_tapbuf_size2[62]->out mux_1level_tapbuf_size2[62]->out_out[39] gvdd_load 0 inv size=1
Xload_inv[240]_no0 mux_1level_tapbuf_size2[62]->out mux_1level_tapbuf_size2[62]->out_out[40] gvdd_load 0 inv size=1
Xload_inv[241]_no0 mux_1level_tapbuf_size2[62]->out mux_1level_tapbuf_size2[62]->out_out[41] gvdd_load 0 inv size=1
Xload_inv[242]_no0 mux_1level_tapbuf_size2[62]->out mux_1level_tapbuf_size2[62]->out_out[42] gvdd_load 0 inv size=1
Xload_inv[243]_no0 mux_1level_tapbuf_size2[62]->out mux_1level_tapbuf_size2[62]->out_out[43] gvdd_load 0 inv size=1
Xload_inv[244]_no0 mux_1level_tapbuf_size2[62]->out mux_1level_tapbuf_size2[62]->out_out[44] gvdd_load 0 inv size=1
Xload_inv[245]_no0 mux_1level_tapbuf_size2[62]->out mux_1level_tapbuf_size2[62]->out_out[45] gvdd_load 0 inv size=1
Xload_inv[246]_no0 mux_1level_tapbuf_size2[62]->out mux_1level_tapbuf_size2[62]->out_out[46] gvdd_load 0 inv size=1
Xload_inv[247]_no0 mux_1level_tapbuf_size2[62]->out mux_1level_tapbuf_size2[62]->out_out[47] gvdd_load 0 inv size=1
Xload_inv[248]_no0 mux_1level_tapbuf_size2[62]->out mux_1level_tapbuf_size2[62]->out_out[48] gvdd_load 0 inv size=1
Xload_inv[249]_no0 mux_1level_tapbuf_size2[62]->out mux_1level_tapbuf_size2[62]->out_out[49] gvdd_load 0 inv size=1
Xload_inv[250]_no0 mux_1level_tapbuf_size2[62]->out mux_1level_tapbuf_size2[62]->out_out[50] gvdd_load 0 inv size=1
Xload_inv[251]_no0 mux_1level_tapbuf_size2[62]->out mux_1level_tapbuf_size2[62]->out_out[51] gvdd_load 0 inv size=1
Xload_inv[252]_no0 mux_1level_tapbuf_size2[62]->out mux_1level_tapbuf_size2[62]->out_out[52] gvdd_load 0 inv size=1
Xload_inv[253]_no0 mux_1level_tapbuf_size2[62]->out mux_1level_tapbuf_size2[62]->out_out[53] gvdd_load 0 inv size=1
Xload_inv[254]_no0 mux_1level_tapbuf_size2[62]->out mux_1level_tapbuf_size2[62]->out_out[54] gvdd_load 0 inv size=1
Xload_inv[255]_no0 mux_1level_tapbuf_size2[62]->out mux_1level_tapbuf_size2[62]->out_out[55] gvdd_load 0 inv size=1
Xload_inv[256]_no0 mux_1level_tapbuf_size2[62]->out mux_1level_tapbuf_size2[62]->out_out[56] gvdd_load 0 inv size=1
Xload_inv[257]_no0 mux_1level_tapbuf_size2[62]->out mux_1level_tapbuf_size2[62]->out_out[57] gvdd_load 0 inv size=1
Xload_inv[258]_no0 mux_1level_tapbuf_size2[62]->out mux_1level_tapbuf_size2[62]->out_out[58] gvdd_load 0 inv size=1
Xload_inv[259]_no0 mux_1level_tapbuf_size2[62]->out mux_1level_tapbuf_size2[62]->out_out[59] gvdd_load 0 inv size=1
Xload_inv[260]_no0 mux_1level_tapbuf_size2[62]->out load_inv[260]_out gvdd_load 0 inv size=1
Xload_inv[261]_no0 mux_1level_tapbuf_size2[62]->out load_inv[261]_out gvdd_load 0 inv size=1
Xload_inv[262]_no0 mux_1level_tapbuf_size2[62]->out load_inv[262]_out gvdd_load 0 inv size=1
Xload_inv[263]_no0 mux_1level_tapbuf_size2[62]->out load_inv[263]_out gvdd_load 0 inv size=1
Xload_inv[264]_no0 mux_1level_tapbuf_size2[62]->out load_inv[264]_out gvdd_load 0 inv size=1
Xload_inv[265]_no0 mux_1level_tapbuf_size2[62]->out load_inv[265]_out gvdd_load 0 inv size=1
Xload_inv[266]_no0 mux_1level_tapbuf_size2[62]->out load_inv[266]_out gvdd_load 0 inv size=1
Xload_inv[267]_no0 mux_1level_tapbuf_size2[62]->out load_inv[267]_out gvdd_load 0 inv size=1
Xload_inv[268]_no0 mux_1level_tapbuf_size2[62]->out load_inv[268]_out gvdd_load 0 inv size=1
Xload_inv[269]_no0 mux_1level_tapbuf_size2[62]->out load_inv[269]_out gvdd_load 0 inv size=1
.meas tran sum_leakage_power_pb_mux[0to62]
+          param='sum_leakage_power_pb_mux[0to61]+leakage_idle_mux2[62]_out[0]_mux1'
.meas tran sum_energy_per_cycle_pb_mux[0to62]
+          param='sum_energy_per_cycle_pb_mux[0to61]+energy_per_cycle_idle_mux2[62]_out[0]_mux1'
Xmux_1level_tapbuf_size2[63] mux_1level_tapbuf_size2[63]->in[0] mux_1level_tapbuf_size2[63]->in[1] mux_1level_tapbuf_size2[63]->out sram[963]->outb sram[963]->out gvdd_mux_1level_tapbuf_size2[63] 0 mux_1level_tapbuf_size2
***** SRAM bits for MUX[63], level=1, select_path_id=0. *****
*****1*****
Xsram[963] sram->in sram[963]->out sram[963]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[963]->out) 0
.nodeset V(sram[963]->outb) vsp
***** Signal mux_1level_tapbuf_size2[63]->in[0] density = 0.2026, probability=0.5018.*****
Vmux_1level_tapbuf_size2[63]->in[0] mux_1level_tapbuf_size2[63]->in[0] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_1level_tapbuf_size2[63]->in[1] density = 0.2026, probability=0.5018.*****
Vmux_1level_tapbuf_size2[63]->in[1] mux_1level_tapbuf_size2[63]->in[1] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
Vgvdd_mux_1level_tapbuf_size2[63] gvdd_mux_1level_tapbuf_size2[63] 0 vsp
***** Measurements *****
***** Rise delay *****
.meas tran delay_rise_idle_mux2[63]_out[0]_mux1 trig v(mux_1level_tapbuf_size2[63]->in[0]) val='input_thres_pct_rise*vsp' rise=1 td='clock_period'
+          targ v(mux_1level_tapbuf_size2[63]->out) val='output_thres_pct_rise*vsp' rise=1 td='clock_period'
***** Fall delay *****
.meas tran delay_fall_idle_mux2[63]_out[0]_mux1 trig v(mux_1level_tapbuf_size2[63]->in[0]) val='input_thres_pct_fall*vsp' fall=1 td='clock_period'
+          targ v(mux_1level_tapbuf_size2[63]->out) val='output_thres_pct_fall*vsp' fall=1 td='clock_period'
***** Rise timing period *****
.meas start_rise_idle_mux2[63]_out[0]_mux1 when v(mux_1level_tapbuf_size2[63]->in[0])='slew_lower_thres_pct_rise*vsp' rise=1 td='clock_period'
.meas tran switch_rise_idle_mux2[63]_out[0]_mux1 trig v(mux_1level_tapbuf_size2[63]->in[0]) val='slew_lower_thres_pct_rise*vsp' rise=1 td='clock_period'
+          targ v(mux_1level_tapbuf_size2[63]->out) val='slew_upper_thres_pct_rise*vsp' rise=1 td='clock_period'
***** Fall timing period *****
.meas start_fall_idle_mux2[63]_out[0]_mux1 when v(mux_1level_tapbuf_size2[63]->in[0])='slew_lower_thres_pct_fall*vsp' fall=1 td='clock_period'
.meas tran switch_fall_idle_mux2[63]_out[0]_mux1 trig v(mux_1level_tapbuf_size2[63]->in[0]) val='slew_lower_thres_pct_fall*vsp' fall=1 td='clock_period'
+          targ v(mux_1level_tapbuf_size2[63]->out) val='slew_upper_thres_pct_fall*vsp' fall=1 td='clock_period'
***** Leakage Power Measurement *****
.meas tran mux_1level_tapbuf_size2[63]_leakage_power avg p(Vgvdd_mux_1level_tapbuf_size2[63]) from=0 to='clock_period'
.meas tran leakage_idle_mux2[63]_out[0]_mux1 param='mux_1level_tapbuf_size2[63]_leakage_power'
***** Dynamic Power Measurement *****
.meas tran mux_1level_tapbuf_size2[63]_dynamic_power avg p(Vgvdd_mux_1level_tapbuf_size2[63]) from='clock_period' to='6*clock_period'
.meas tran mux_1level_tapbuf_size2[63]_energy_per_cycle param='mux_1level_tapbuf_size2[63]_dynamic_power*clock_period'
.meas tran dynamic_power_idle_mux2[63]_out[0]_mux1  param='mux_1level_tapbuf_size2[63]_dynamic_power'
.meas tran energy_per_cycle_idle_mux2[63]_out[0]_mux1  param='dynamic_power_idle_mux2[63]_out[0]_mux1*clock_period'
.meas tran dynamic_rise_idle_mux2[63]_out[0]_mux1 avg p(Vgvdd_mux_1level_tapbuf_size2[63]) from='start_rise_idle_mux2[63]_out[0]_mux1' to='start_rise_idle_mux2[63]_out[0]_mux1+switch_rise_idle_mux2[63]_out[0]_mux1'
.meas tran dynamic_fall_idle_mux2[63]_out[0]_mux1 avg p(Vgvdd_mux_1level_tapbuf_size2[63]) from='start_fall_idle_mux2[63]_out[0]_mux1' to='start_fall_idle_mux2[63]_out[0]_mux1+switch_fall_idle_mux2[63]_out[0]_mux1'
.meas tran sum_leakage_power_mux[0to63]
+          param='sum_leakage_power_mux[0to62]+leakage_idle_mux2[63]_out[0]_mux1'
.meas tran sum_energy_per_cycle_mux[0to63]
+          param='sum_energy_per_cycle_mux[0to62]+energy_per_cycle_idle_mux2[63]_out[0]_mux1'
Xload_inv[270]_no0 mux_1level_tapbuf_size2[63]->out mux_1level_tapbuf_size2[63]->out_out[0] gvdd_load 0 inv size=1
Xload_inv[271]_no0 mux_1level_tapbuf_size2[63]->out mux_1level_tapbuf_size2[63]->out_out[1] gvdd_load 0 inv size=1
Xload_inv[272]_no0 mux_1level_tapbuf_size2[63]->out mux_1level_tapbuf_size2[63]->out_out[2] gvdd_load 0 inv size=1
Xload_inv[273]_no0 mux_1level_tapbuf_size2[63]->out mux_1level_tapbuf_size2[63]->out_out[3] gvdd_load 0 inv size=1
Xload_inv[274]_no0 mux_1level_tapbuf_size2[63]->out mux_1level_tapbuf_size2[63]->out_out[4] gvdd_load 0 inv size=1
Xload_inv[275]_no0 mux_1level_tapbuf_size2[63]->out mux_1level_tapbuf_size2[63]->out_out[5] gvdd_load 0 inv size=1
Xload_inv[276]_no0 mux_1level_tapbuf_size2[63]->out mux_1level_tapbuf_size2[63]->out_out[6] gvdd_load 0 inv size=1
Xload_inv[277]_no0 mux_1level_tapbuf_size2[63]->out mux_1level_tapbuf_size2[63]->out_out[7] gvdd_load 0 inv size=1
Xload_inv[278]_no0 mux_1level_tapbuf_size2[63]->out mux_1level_tapbuf_size2[63]->out_out[8] gvdd_load 0 inv size=1
Xload_inv[279]_no0 mux_1level_tapbuf_size2[63]->out mux_1level_tapbuf_size2[63]->out_out[9] gvdd_load 0 inv size=1
Xload_inv[280]_no0 mux_1level_tapbuf_size2[63]->out mux_1level_tapbuf_size2[63]->out_out[10] gvdd_load 0 inv size=1
Xload_inv[281]_no0 mux_1level_tapbuf_size2[63]->out mux_1level_tapbuf_size2[63]->out_out[11] gvdd_load 0 inv size=1
Xload_inv[282]_no0 mux_1level_tapbuf_size2[63]->out mux_1level_tapbuf_size2[63]->out_out[12] gvdd_load 0 inv size=1
Xload_inv[283]_no0 mux_1level_tapbuf_size2[63]->out mux_1level_tapbuf_size2[63]->out_out[13] gvdd_load 0 inv size=1
Xload_inv[284]_no0 mux_1level_tapbuf_size2[63]->out mux_1level_tapbuf_size2[63]->out_out[14] gvdd_load 0 inv size=1
Xload_inv[285]_no0 mux_1level_tapbuf_size2[63]->out mux_1level_tapbuf_size2[63]->out_out[15] gvdd_load 0 inv size=1
Xload_inv[286]_no0 mux_1level_tapbuf_size2[63]->out mux_1level_tapbuf_size2[63]->out_out[16] gvdd_load 0 inv size=1
Xload_inv[287]_no0 mux_1level_tapbuf_size2[63]->out mux_1level_tapbuf_size2[63]->out_out[17] gvdd_load 0 inv size=1
Xload_inv[288]_no0 mux_1level_tapbuf_size2[63]->out mux_1level_tapbuf_size2[63]->out_out[18] gvdd_load 0 inv size=1
Xload_inv[289]_no0 mux_1level_tapbuf_size2[63]->out mux_1level_tapbuf_size2[63]->out_out[19] gvdd_load 0 inv size=1
Xload_inv[290]_no0 mux_1level_tapbuf_size2[63]->out mux_1level_tapbuf_size2[63]->out_out[20] gvdd_load 0 inv size=1
Xload_inv[291]_no0 mux_1level_tapbuf_size2[63]->out mux_1level_tapbuf_size2[63]->out_out[21] gvdd_load 0 inv size=1
Xload_inv[292]_no0 mux_1level_tapbuf_size2[63]->out mux_1level_tapbuf_size2[63]->out_out[22] gvdd_load 0 inv size=1
Xload_inv[293]_no0 mux_1level_tapbuf_size2[63]->out mux_1level_tapbuf_size2[63]->out_out[23] gvdd_load 0 inv size=1
Xload_inv[294]_no0 mux_1level_tapbuf_size2[63]->out mux_1level_tapbuf_size2[63]->out_out[24] gvdd_load 0 inv size=1
Xload_inv[295]_no0 mux_1level_tapbuf_size2[63]->out mux_1level_tapbuf_size2[63]->out_out[25] gvdd_load 0 inv size=1
Xload_inv[296]_no0 mux_1level_tapbuf_size2[63]->out mux_1level_tapbuf_size2[63]->out_out[26] gvdd_load 0 inv size=1
Xload_inv[297]_no0 mux_1level_tapbuf_size2[63]->out mux_1level_tapbuf_size2[63]->out_out[27] gvdd_load 0 inv size=1
Xload_inv[298]_no0 mux_1level_tapbuf_size2[63]->out mux_1level_tapbuf_size2[63]->out_out[28] gvdd_load 0 inv size=1
Xload_inv[299]_no0 mux_1level_tapbuf_size2[63]->out mux_1level_tapbuf_size2[63]->out_out[29] gvdd_load 0 inv size=1
Xload_inv[300]_no0 mux_1level_tapbuf_size2[63]->out mux_1level_tapbuf_size2[63]->out_out[30] gvdd_load 0 inv size=1
Xload_inv[301]_no0 mux_1level_tapbuf_size2[63]->out mux_1level_tapbuf_size2[63]->out_out[31] gvdd_load 0 inv size=1
Xload_inv[302]_no0 mux_1level_tapbuf_size2[63]->out mux_1level_tapbuf_size2[63]->out_out[32] gvdd_load 0 inv size=1
Xload_inv[303]_no0 mux_1level_tapbuf_size2[63]->out mux_1level_tapbuf_size2[63]->out_out[33] gvdd_load 0 inv size=1
Xload_inv[304]_no0 mux_1level_tapbuf_size2[63]->out mux_1level_tapbuf_size2[63]->out_out[34] gvdd_load 0 inv size=1
Xload_inv[305]_no0 mux_1level_tapbuf_size2[63]->out mux_1level_tapbuf_size2[63]->out_out[35] gvdd_load 0 inv size=1
Xload_inv[306]_no0 mux_1level_tapbuf_size2[63]->out mux_1level_tapbuf_size2[63]->out_out[36] gvdd_load 0 inv size=1
Xload_inv[307]_no0 mux_1level_tapbuf_size2[63]->out mux_1level_tapbuf_size2[63]->out_out[37] gvdd_load 0 inv size=1
Xload_inv[308]_no0 mux_1level_tapbuf_size2[63]->out mux_1level_tapbuf_size2[63]->out_out[38] gvdd_load 0 inv size=1
Xload_inv[309]_no0 mux_1level_tapbuf_size2[63]->out mux_1level_tapbuf_size2[63]->out_out[39] gvdd_load 0 inv size=1
Xload_inv[310]_no0 mux_1level_tapbuf_size2[63]->out mux_1level_tapbuf_size2[63]->out_out[40] gvdd_load 0 inv size=1
Xload_inv[311]_no0 mux_1level_tapbuf_size2[63]->out mux_1level_tapbuf_size2[63]->out_out[41] gvdd_load 0 inv size=1
Xload_inv[312]_no0 mux_1level_tapbuf_size2[63]->out mux_1level_tapbuf_size2[63]->out_out[42] gvdd_load 0 inv size=1
Xload_inv[313]_no0 mux_1level_tapbuf_size2[63]->out mux_1level_tapbuf_size2[63]->out_out[43] gvdd_load 0 inv size=1
Xload_inv[314]_no0 mux_1level_tapbuf_size2[63]->out mux_1level_tapbuf_size2[63]->out_out[44] gvdd_load 0 inv size=1
Xload_inv[315]_no0 mux_1level_tapbuf_size2[63]->out mux_1level_tapbuf_size2[63]->out_out[45] gvdd_load 0 inv size=1
Xload_inv[316]_no0 mux_1level_tapbuf_size2[63]->out mux_1level_tapbuf_size2[63]->out_out[46] gvdd_load 0 inv size=1
Xload_inv[317]_no0 mux_1level_tapbuf_size2[63]->out mux_1level_tapbuf_size2[63]->out_out[47] gvdd_load 0 inv size=1
Xload_inv[318]_no0 mux_1level_tapbuf_size2[63]->out mux_1level_tapbuf_size2[63]->out_out[48] gvdd_load 0 inv size=1
Xload_inv[319]_no0 mux_1level_tapbuf_size2[63]->out mux_1level_tapbuf_size2[63]->out_out[49] gvdd_load 0 inv size=1
Xload_inv[320]_no0 mux_1level_tapbuf_size2[63]->out mux_1level_tapbuf_size2[63]->out_out[50] gvdd_load 0 inv size=1
Xload_inv[321]_no0 mux_1level_tapbuf_size2[63]->out mux_1level_tapbuf_size2[63]->out_out[51] gvdd_load 0 inv size=1
Xload_inv[322]_no0 mux_1level_tapbuf_size2[63]->out mux_1level_tapbuf_size2[63]->out_out[52] gvdd_load 0 inv size=1
Xload_inv[323]_no0 mux_1level_tapbuf_size2[63]->out mux_1level_tapbuf_size2[63]->out_out[53] gvdd_load 0 inv size=1
Xload_inv[324]_no0 mux_1level_tapbuf_size2[63]->out mux_1level_tapbuf_size2[63]->out_out[54] gvdd_load 0 inv size=1
Xload_inv[325]_no0 mux_1level_tapbuf_size2[63]->out mux_1level_tapbuf_size2[63]->out_out[55] gvdd_load 0 inv size=1
Xload_inv[326]_no0 mux_1level_tapbuf_size2[63]->out mux_1level_tapbuf_size2[63]->out_out[56] gvdd_load 0 inv size=1
Xload_inv[327]_no0 mux_1level_tapbuf_size2[63]->out mux_1level_tapbuf_size2[63]->out_out[57] gvdd_load 0 inv size=1
Xload_inv[328]_no0 mux_1level_tapbuf_size2[63]->out mux_1level_tapbuf_size2[63]->out_out[58] gvdd_load 0 inv size=1
Xload_inv[329]_no0 mux_1level_tapbuf_size2[63]->out mux_1level_tapbuf_size2[63]->out_out[59] gvdd_load 0 inv size=1
Xload_inv[330]_no0 mux_1level_tapbuf_size2[63]->out load_inv[330]_out gvdd_load 0 inv size=1
Xload_inv[331]_no0 mux_1level_tapbuf_size2[63]->out load_inv[331]_out gvdd_load 0 inv size=1
Xload_inv[332]_no0 mux_1level_tapbuf_size2[63]->out load_inv[332]_out gvdd_load 0 inv size=1
Xload_inv[333]_no0 mux_1level_tapbuf_size2[63]->out load_inv[333]_out gvdd_load 0 inv size=1
Xload_inv[334]_no0 mux_1level_tapbuf_size2[63]->out load_inv[334]_out gvdd_load 0 inv size=1
Xload_inv[335]_no0 mux_1level_tapbuf_size2[63]->out load_inv[335]_out gvdd_load 0 inv size=1
Xload_inv[336]_no0 mux_1level_tapbuf_size2[63]->out load_inv[336]_out gvdd_load 0 inv size=1
Xload_inv[337]_no0 mux_1level_tapbuf_size2[63]->out load_inv[337]_out gvdd_load 0 inv size=1
Xload_inv[338]_no0 mux_1level_tapbuf_size2[63]->out load_inv[338]_out gvdd_load 0 inv size=1
Xload_inv[339]_no0 mux_1level_tapbuf_size2[63]->out load_inv[339]_out gvdd_load 0 inv size=1
.meas tran sum_leakage_power_pb_mux[0to63]
+          param='sum_leakage_power_pb_mux[0to62]+leakage_idle_mux2[63]_out[0]_mux1'
.meas tran sum_energy_per_cycle_pb_mux[0to63]
+          param='sum_energy_per_cycle_pb_mux[0to62]+energy_per_cycle_idle_mux2[63]_out[0]_mux1'
Xmux_1level_tapbuf_size2[64] mux_1level_tapbuf_size2[64]->in[0] mux_1level_tapbuf_size2[64]->in[1] mux_1level_tapbuf_size2[64]->out sram[964]->outb sram[964]->out gvdd_mux_1level_tapbuf_size2[64] 0 mux_1level_tapbuf_size2
***** SRAM bits for MUX[64], level=1, select_path_id=0. *****
*****1*****
Xsram[964] sram->in sram[964]->out sram[964]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[964]->out) 0
.nodeset V(sram[964]->outb) vsp
***** Signal mux_1level_tapbuf_size2[64]->in[0] density = 0.2026, probability=0.5018.*****
Vmux_1level_tapbuf_size2[64]->in[0] mux_1level_tapbuf_size2[64]->in[0] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_1level_tapbuf_size2[64]->in[1] density = 0.2026, probability=0.5018.*****
Vmux_1level_tapbuf_size2[64]->in[1] mux_1level_tapbuf_size2[64]->in[1] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
Vgvdd_mux_1level_tapbuf_size2[64] gvdd_mux_1level_tapbuf_size2[64] 0 vsp
***** Measurements *****
***** Rise delay *****
.meas tran delay_rise_idle_mux2[64]_out[0]_mux1 trig v(mux_1level_tapbuf_size2[64]->in[0]) val='input_thres_pct_rise*vsp' rise=1 td='clock_period'
+          targ v(mux_1level_tapbuf_size2[64]->out) val='output_thres_pct_rise*vsp' rise=1 td='clock_period'
***** Fall delay *****
.meas tran delay_fall_idle_mux2[64]_out[0]_mux1 trig v(mux_1level_tapbuf_size2[64]->in[0]) val='input_thres_pct_fall*vsp' fall=1 td='clock_period'
+          targ v(mux_1level_tapbuf_size2[64]->out) val='output_thres_pct_fall*vsp' fall=1 td='clock_period'
***** Rise timing period *****
.meas start_rise_idle_mux2[64]_out[0]_mux1 when v(mux_1level_tapbuf_size2[64]->in[0])='slew_lower_thres_pct_rise*vsp' rise=1 td='clock_period'
.meas tran switch_rise_idle_mux2[64]_out[0]_mux1 trig v(mux_1level_tapbuf_size2[64]->in[0]) val='slew_lower_thres_pct_rise*vsp' rise=1 td='clock_period'
+          targ v(mux_1level_tapbuf_size2[64]->out) val='slew_upper_thres_pct_rise*vsp' rise=1 td='clock_period'
***** Fall timing period *****
.meas start_fall_idle_mux2[64]_out[0]_mux1 when v(mux_1level_tapbuf_size2[64]->in[0])='slew_lower_thres_pct_fall*vsp' fall=1 td='clock_period'
.meas tran switch_fall_idle_mux2[64]_out[0]_mux1 trig v(mux_1level_tapbuf_size2[64]->in[0]) val='slew_lower_thres_pct_fall*vsp' fall=1 td='clock_period'
+          targ v(mux_1level_tapbuf_size2[64]->out) val='slew_upper_thres_pct_fall*vsp' fall=1 td='clock_period'
***** Leakage Power Measurement *****
.meas tran mux_1level_tapbuf_size2[64]_leakage_power avg p(Vgvdd_mux_1level_tapbuf_size2[64]) from=0 to='clock_period'
.meas tran leakage_idle_mux2[64]_out[0]_mux1 param='mux_1level_tapbuf_size2[64]_leakage_power'
***** Dynamic Power Measurement *****
.meas tran mux_1level_tapbuf_size2[64]_dynamic_power avg p(Vgvdd_mux_1level_tapbuf_size2[64]) from='clock_period' to='6*clock_period'
.meas tran mux_1level_tapbuf_size2[64]_energy_per_cycle param='mux_1level_tapbuf_size2[64]_dynamic_power*clock_period'
.meas tran dynamic_power_idle_mux2[64]_out[0]_mux1  param='mux_1level_tapbuf_size2[64]_dynamic_power'
.meas tran energy_per_cycle_idle_mux2[64]_out[0]_mux1  param='dynamic_power_idle_mux2[64]_out[0]_mux1*clock_period'
.meas tran dynamic_rise_idle_mux2[64]_out[0]_mux1 avg p(Vgvdd_mux_1level_tapbuf_size2[64]) from='start_rise_idle_mux2[64]_out[0]_mux1' to='start_rise_idle_mux2[64]_out[0]_mux1+switch_rise_idle_mux2[64]_out[0]_mux1'
.meas tran dynamic_fall_idle_mux2[64]_out[0]_mux1 avg p(Vgvdd_mux_1level_tapbuf_size2[64]) from='start_fall_idle_mux2[64]_out[0]_mux1' to='start_fall_idle_mux2[64]_out[0]_mux1+switch_fall_idle_mux2[64]_out[0]_mux1'
.meas tran sum_leakage_power_mux[0to64]
+          param='sum_leakage_power_mux[0to63]+leakage_idle_mux2[64]_out[0]_mux1'
.meas tran sum_energy_per_cycle_mux[0to64]
+          param='sum_energy_per_cycle_mux[0to63]+energy_per_cycle_idle_mux2[64]_out[0]_mux1'
Xload_inv[340]_no0 mux_1level_tapbuf_size2[64]->out mux_1level_tapbuf_size2[64]->out_out[0] gvdd_load 0 inv size=1
Xload_inv[341]_no0 mux_1level_tapbuf_size2[64]->out mux_1level_tapbuf_size2[64]->out_out[1] gvdd_load 0 inv size=1
Xload_inv[342]_no0 mux_1level_tapbuf_size2[64]->out mux_1level_tapbuf_size2[64]->out_out[2] gvdd_load 0 inv size=1
Xload_inv[343]_no0 mux_1level_tapbuf_size2[64]->out mux_1level_tapbuf_size2[64]->out_out[3] gvdd_load 0 inv size=1
Xload_inv[344]_no0 mux_1level_tapbuf_size2[64]->out mux_1level_tapbuf_size2[64]->out_out[4] gvdd_load 0 inv size=1
Xload_inv[345]_no0 mux_1level_tapbuf_size2[64]->out mux_1level_tapbuf_size2[64]->out_out[5] gvdd_load 0 inv size=1
Xload_inv[346]_no0 mux_1level_tapbuf_size2[64]->out mux_1level_tapbuf_size2[64]->out_out[6] gvdd_load 0 inv size=1
Xload_inv[347]_no0 mux_1level_tapbuf_size2[64]->out mux_1level_tapbuf_size2[64]->out_out[7] gvdd_load 0 inv size=1
Xload_inv[348]_no0 mux_1level_tapbuf_size2[64]->out mux_1level_tapbuf_size2[64]->out_out[8] gvdd_load 0 inv size=1
Xload_inv[349]_no0 mux_1level_tapbuf_size2[64]->out mux_1level_tapbuf_size2[64]->out_out[9] gvdd_load 0 inv size=1
Xload_inv[350]_no0 mux_1level_tapbuf_size2[64]->out mux_1level_tapbuf_size2[64]->out_out[10] gvdd_load 0 inv size=1
Xload_inv[351]_no0 mux_1level_tapbuf_size2[64]->out mux_1level_tapbuf_size2[64]->out_out[11] gvdd_load 0 inv size=1
Xload_inv[352]_no0 mux_1level_tapbuf_size2[64]->out mux_1level_tapbuf_size2[64]->out_out[12] gvdd_load 0 inv size=1
Xload_inv[353]_no0 mux_1level_tapbuf_size2[64]->out mux_1level_tapbuf_size2[64]->out_out[13] gvdd_load 0 inv size=1
Xload_inv[354]_no0 mux_1level_tapbuf_size2[64]->out mux_1level_tapbuf_size2[64]->out_out[14] gvdd_load 0 inv size=1
Xload_inv[355]_no0 mux_1level_tapbuf_size2[64]->out mux_1level_tapbuf_size2[64]->out_out[15] gvdd_load 0 inv size=1
Xload_inv[356]_no0 mux_1level_tapbuf_size2[64]->out mux_1level_tapbuf_size2[64]->out_out[16] gvdd_load 0 inv size=1
Xload_inv[357]_no0 mux_1level_tapbuf_size2[64]->out mux_1level_tapbuf_size2[64]->out_out[17] gvdd_load 0 inv size=1
Xload_inv[358]_no0 mux_1level_tapbuf_size2[64]->out mux_1level_tapbuf_size2[64]->out_out[18] gvdd_load 0 inv size=1
Xload_inv[359]_no0 mux_1level_tapbuf_size2[64]->out mux_1level_tapbuf_size2[64]->out_out[19] gvdd_load 0 inv size=1
Xload_inv[360]_no0 mux_1level_tapbuf_size2[64]->out mux_1level_tapbuf_size2[64]->out_out[20] gvdd_load 0 inv size=1
Xload_inv[361]_no0 mux_1level_tapbuf_size2[64]->out mux_1level_tapbuf_size2[64]->out_out[21] gvdd_load 0 inv size=1
Xload_inv[362]_no0 mux_1level_tapbuf_size2[64]->out mux_1level_tapbuf_size2[64]->out_out[22] gvdd_load 0 inv size=1
Xload_inv[363]_no0 mux_1level_tapbuf_size2[64]->out mux_1level_tapbuf_size2[64]->out_out[23] gvdd_load 0 inv size=1
Xload_inv[364]_no0 mux_1level_tapbuf_size2[64]->out mux_1level_tapbuf_size2[64]->out_out[24] gvdd_load 0 inv size=1
Xload_inv[365]_no0 mux_1level_tapbuf_size2[64]->out mux_1level_tapbuf_size2[64]->out_out[25] gvdd_load 0 inv size=1
Xload_inv[366]_no0 mux_1level_tapbuf_size2[64]->out mux_1level_tapbuf_size2[64]->out_out[26] gvdd_load 0 inv size=1
Xload_inv[367]_no0 mux_1level_tapbuf_size2[64]->out mux_1level_tapbuf_size2[64]->out_out[27] gvdd_load 0 inv size=1
Xload_inv[368]_no0 mux_1level_tapbuf_size2[64]->out mux_1level_tapbuf_size2[64]->out_out[28] gvdd_load 0 inv size=1
Xload_inv[369]_no0 mux_1level_tapbuf_size2[64]->out mux_1level_tapbuf_size2[64]->out_out[29] gvdd_load 0 inv size=1
Xload_inv[370]_no0 mux_1level_tapbuf_size2[64]->out mux_1level_tapbuf_size2[64]->out_out[30] gvdd_load 0 inv size=1
Xload_inv[371]_no0 mux_1level_tapbuf_size2[64]->out mux_1level_tapbuf_size2[64]->out_out[31] gvdd_load 0 inv size=1
Xload_inv[372]_no0 mux_1level_tapbuf_size2[64]->out mux_1level_tapbuf_size2[64]->out_out[32] gvdd_load 0 inv size=1
Xload_inv[373]_no0 mux_1level_tapbuf_size2[64]->out mux_1level_tapbuf_size2[64]->out_out[33] gvdd_load 0 inv size=1
Xload_inv[374]_no0 mux_1level_tapbuf_size2[64]->out mux_1level_tapbuf_size2[64]->out_out[34] gvdd_load 0 inv size=1
Xload_inv[375]_no0 mux_1level_tapbuf_size2[64]->out mux_1level_tapbuf_size2[64]->out_out[35] gvdd_load 0 inv size=1
Xload_inv[376]_no0 mux_1level_tapbuf_size2[64]->out mux_1level_tapbuf_size2[64]->out_out[36] gvdd_load 0 inv size=1
Xload_inv[377]_no0 mux_1level_tapbuf_size2[64]->out mux_1level_tapbuf_size2[64]->out_out[37] gvdd_load 0 inv size=1
Xload_inv[378]_no0 mux_1level_tapbuf_size2[64]->out mux_1level_tapbuf_size2[64]->out_out[38] gvdd_load 0 inv size=1
Xload_inv[379]_no0 mux_1level_tapbuf_size2[64]->out mux_1level_tapbuf_size2[64]->out_out[39] gvdd_load 0 inv size=1
Xload_inv[380]_no0 mux_1level_tapbuf_size2[64]->out mux_1level_tapbuf_size2[64]->out_out[40] gvdd_load 0 inv size=1
Xload_inv[381]_no0 mux_1level_tapbuf_size2[64]->out mux_1level_tapbuf_size2[64]->out_out[41] gvdd_load 0 inv size=1
Xload_inv[382]_no0 mux_1level_tapbuf_size2[64]->out mux_1level_tapbuf_size2[64]->out_out[42] gvdd_load 0 inv size=1
Xload_inv[383]_no0 mux_1level_tapbuf_size2[64]->out mux_1level_tapbuf_size2[64]->out_out[43] gvdd_load 0 inv size=1
Xload_inv[384]_no0 mux_1level_tapbuf_size2[64]->out mux_1level_tapbuf_size2[64]->out_out[44] gvdd_load 0 inv size=1
Xload_inv[385]_no0 mux_1level_tapbuf_size2[64]->out mux_1level_tapbuf_size2[64]->out_out[45] gvdd_load 0 inv size=1
Xload_inv[386]_no0 mux_1level_tapbuf_size2[64]->out mux_1level_tapbuf_size2[64]->out_out[46] gvdd_load 0 inv size=1
Xload_inv[387]_no0 mux_1level_tapbuf_size2[64]->out mux_1level_tapbuf_size2[64]->out_out[47] gvdd_load 0 inv size=1
Xload_inv[388]_no0 mux_1level_tapbuf_size2[64]->out mux_1level_tapbuf_size2[64]->out_out[48] gvdd_load 0 inv size=1
Xload_inv[389]_no0 mux_1level_tapbuf_size2[64]->out mux_1level_tapbuf_size2[64]->out_out[49] gvdd_load 0 inv size=1
Xload_inv[390]_no0 mux_1level_tapbuf_size2[64]->out mux_1level_tapbuf_size2[64]->out_out[50] gvdd_load 0 inv size=1
Xload_inv[391]_no0 mux_1level_tapbuf_size2[64]->out mux_1level_tapbuf_size2[64]->out_out[51] gvdd_load 0 inv size=1
Xload_inv[392]_no0 mux_1level_tapbuf_size2[64]->out mux_1level_tapbuf_size2[64]->out_out[52] gvdd_load 0 inv size=1
Xload_inv[393]_no0 mux_1level_tapbuf_size2[64]->out mux_1level_tapbuf_size2[64]->out_out[53] gvdd_load 0 inv size=1
Xload_inv[394]_no0 mux_1level_tapbuf_size2[64]->out mux_1level_tapbuf_size2[64]->out_out[54] gvdd_load 0 inv size=1
Xload_inv[395]_no0 mux_1level_tapbuf_size2[64]->out mux_1level_tapbuf_size2[64]->out_out[55] gvdd_load 0 inv size=1
Xload_inv[396]_no0 mux_1level_tapbuf_size2[64]->out mux_1level_tapbuf_size2[64]->out_out[56] gvdd_load 0 inv size=1
Xload_inv[397]_no0 mux_1level_tapbuf_size2[64]->out mux_1level_tapbuf_size2[64]->out_out[57] gvdd_load 0 inv size=1
Xload_inv[398]_no0 mux_1level_tapbuf_size2[64]->out mux_1level_tapbuf_size2[64]->out_out[58] gvdd_load 0 inv size=1
Xload_inv[399]_no0 mux_1level_tapbuf_size2[64]->out mux_1level_tapbuf_size2[64]->out_out[59] gvdd_load 0 inv size=1
Xload_inv[400]_no0 mux_1level_tapbuf_size2[64]->out load_inv[400]_out gvdd_load 0 inv size=1
Xload_inv[401]_no0 mux_1level_tapbuf_size2[64]->out load_inv[401]_out gvdd_load 0 inv size=1
Xload_inv[402]_no0 mux_1level_tapbuf_size2[64]->out load_inv[402]_out gvdd_load 0 inv size=1
Xload_inv[403]_no0 mux_1level_tapbuf_size2[64]->out load_inv[403]_out gvdd_load 0 inv size=1
Xload_inv[404]_no0 mux_1level_tapbuf_size2[64]->out load_inv[404]_out gvdd_load 0 inv size=1
Xload_inv[405]_no0 mux_1level_tapbuf_size2[64]->out load_inv[405]_out gvdd_load 0 inv size=1
Xload_inv[406]_no0 mux_1level_tapbuf_size2[64]->out load_inv[406]_out gvdd_load 0 inv size=1
Xload_inv[407]_no0 mux_1level_tapbuf_size2[64]->out load_inv[407]_out gvdd_load 0 inv size=1
Xload_inv[408]_no0 mux_1level_tapbuf_size2[64]->out load_inv[408]_out gvdd_load 0 inv size=1
Xload_inv[409]_no0 mux_1level_tapbuf_size2[64]->out load_inv[409]_out gvdd_load 0 inv size=1
.meas tran sum_leakage_power_pb_mux[0to64]
+          param='sum_leakage_power_pb_mux[0to63]+leakage_idle_mux2[64]_out[0]_mux1'
.meas tran sum_energy_per_cycle_pb_mux[0to64]
+          param='sum_energy_per_cycle_pb_mux[0to63]+energy_per_cycle_idle_mux2[64]_out[0]_mux1'
Xmux_1level_tapbuf_size2[65] mux_1level_tapbuf_size2[65]->in[0] mux_1level_tapbuf_size2[65]->in[1] mux_1level_tapbuf_size2[65]->out sram[965]->outb sram[965]->out gvdd_mux_1level_tapbuf_size2[65] 0 mux_1level_tapbuf_size2
***** SRAM bits for MUX[65], level=1, select_path_id=0. *****
*****1*****
Xsram[965] sram->in sram[965]->out sram[965]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[965]->out) 0
.nodeset V(sram[965]->outb) vsp
***** Signal mux_1level_tapbuf_size2[65]->in[0] density = 0.2026, probability=0.5018.*****
Vmux_1level_tapbuf_size2[65]->in[0] mux_1level_tapbuf_size2[65]->in[0] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_1level_tapbuf_size2[65]->in[1] density = 0.2026, probability=0.5018.*****
Vmux_1level_tapbuf_size2[65]->in[1] mux_1level_tapbuf_size2[65]->in[1] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
Vgvdd_mux_1level_tapbuf_size2[65] gvdd_mux_1level_tapbuf_size2[65] 0 vsp
***** Measurements *****
***** Rise delay *****
.meas tran delay_rise_idle_mux2[65]_out[0]_mux1 trig v(mux_1level_tapbuf_size2[65]->in[0]) val='input_thres_pct_rise*vsp' rise=1 td='clock_period'
+          targ v(mux_1level_tapbuf_size2[65]->out) val='output_thres_pct_rise*vsp' rise=1 td='clock_period'
***** Fall delay *****
.meas tran delay_fall_idle_mux2[65]_out[0]_mux1 trig v(mux_1level_tapbuf_size2[65]->in[0]) val='input_thres_pct_fall*vsp' fall=1 td='clock_period'
+          targ v(mux_1level_tapbuf_size2[65]->out) val='output_thres_pct_fall*vsp' fall=1 td='clock_period'
***** Rise timing period *****
.meas start_rise_idle_mux2[65]_out[0]_mux1 when v(mux_1level_tapbuf_size2[65]->in[0])='slew_lower_thres_pct_rise*vsp' rise=1 td='clock_period'
.meas tran switch_rise_idle_mux2[65]_out[0]_mux1 trig v(mux_1level_tapbuf_size2[65]->in[0]) val='slew_lower_thres_pct_rise*vsp' rise=1 td='clock_period'
+          targ v(mux_1level_tapbuf_size2[65]->out) val='slew_upper_thres_pct_rise*vsp' rise=1 td='clock_period'
***** Fall timing period *****
.meas start_fall_idle_mux2[65]_out[0]_mux1 when v(mux_1level_tapbuf_size2[65]->in[0])='slew_lower_thres_pct_fall*vsp' fall=1 td='clock_period'
.meas tran switch_fall_idle_mux2[65]_out[0]_mux1 trig v(mux_1level_tapbuf_size2[65]->in[0]) val='slew_lower_thres_pct_fall*vsp' fall=1 td='clock_period'
+          targ v(mux_1level_tapbuf_size2[65]->out) val='slew_upper_thres_pct_fall*vsp' fall=1 td='clock_period'
***** Leakage Power Measurement *****
.meas tran mux_1level_tapbuf_size2[65]_leakage_power avg p(Vgvdd_mux_1level_tapbuf_size2[65]) from=0 to='clock_period'
.meas tran leakage_idle_mux2[65]_out[0]_mux1 param='mux_1level_tapbuf_size2[65]_leakage_power'
***** Dynamic Power Measurement *****
.meas tran mux_1level_tapbuf_size2[65]_dynamic_power avg p(Vgvdd_mux_1level_tapbuf_size2[65]) from='clock_period' to='6*clock_period'
.meas tran mux_1level_tapbuf_size2[65]_energy_per_cycle param='mux_1level_tapbuf_size2[65]_dynamic_power*clock_period'
.meas tran dynamic_power_idle_mux2[65]_out[0]_mux1  param='mux_1level_tapbuf_size2[65]_dynamic_power'
.meas tran energy_per_cycle_idle_mux2[65]_out[0]_mux1  param='dynamic_power_idle_mux2[65]_out[0]_mux1*clock_period'
.meas tran dynamic_rise_idle_mux2[65]_out[0]_mux1 avg p(Vgvdd_mux_1level_tapbuf_size2[65]) from='start_rise_idle_mux2[65]_out[0]_mux1' to='start_rise_idle_mux2[65]_out[0]_mux1+switch_rise_idle_mux2[65]_out[0]_mux1'
.meas tran dynamic_fall_idle_mux2[65]_out[0]_mux1 avg p(Vgvdd_mux_1level_tapbuf_size2[65]) from='start_fall_idle_mux2[65]_out[0]_mux1' to='start_fall_idle_mux2[65]_out[0]_mux1+switch_fall_idle_mux2[65]_out[0]_mux1'
.meas tran sum_leakage_power_mux[0to65]
+          param='sum_leakage_power_mux[0to64]+leakage_idle_mux2[65]_out[0]_mux1'
.meas tran sum_energy_per_cycle_mux[0to65]
+          param='sum_energy_per_cycle_mux[0to64]+energy_per_cycle_idle_mux2[65]_out[0]_mux1'
Xload_inv[410]_no0 mux_1level_tapbuf_size2[65]->out mux_1level_tapbuf_size2[65]->out_out[0] gvdd_load 0 inv size=1
Xload_inv[411]_no0 mux_1level_tapbuf_size2[65]->out mux_1level_tapbuf_size2[65]->out_out[1] gvdd_load 0 inv size=1
Xload_inv[412]_no0 mux_1level_tapbuf_size2[65]->out mux_1level_tapbuf_size2[65]->out_out[2] gvdd_load 0 inv size=1
Xload_inv[413]_no0 mux_1level_tapbuf_size2[65]->out mux_1level_tapbuf_size2[65]->out_out[3] gvdd_load 0 inv size=1
Xload_inv[414]_no0 mux_1level_tapbuf_size2[65]->out mux_1level_tapbuf_size2[65]->out_out[4] gvdd_load 0 inv size=1
Xload_inv[415]_no0 mux_1level_tapbuf_size2[65]->out mux_1level_tapbuf_size2[65]->out_out[5] gvdd_load 0 inv size=1
Xload_inv[416]_no0 mux_1level_tapbuf_size2[65]->out mux_1level_tapbuf_size2[65]->out_out[6] gvdd_load 0 inv size=1
Xload_inv[417]_no0 mux_1level_tapbuf_size2[65]->out mux_1level_tapbuf_size2[65]->out_out[7] gvdd_load 0 inv size=1
Xload_inv[418]_no0 mux_1level_tapbuf_size2[65]->out mux_1level_tapbuf_size2[65]->out_out[8] gvdd_load 0 inv size=1
Xload_inv[419]_no0 mux_1level_tapbuf_size2[65]->out mux_1level_tapbuf_size2[65]->out_out[9] gvdd_load 0 inv size=1
Xload_inv[420]_no0 mux_1level_tapbuf_size2[65]->out mux_1level_tapbuf_size2[65]->out_out[10] gvdd_load 0 inv size=1
Xload_inv[421]_no0 mux_1level_tapbuf_size2[65]->out mux_1level_tapbuf_size2[65]->out_out[11] gvdd_load 0 inv size=1
Xload_inv[422]_no0 mux_1level_tapbuf_size2[65]->out mux_1level_tapbuf_size2[65]->out_out[12] gvdd_load 0 inv size=1
Xload_inv[423]_no0 mux_1level_tapbuf_size2[65]->out mux_1level_tapbuf_size2[65]->out_out[13] gvdd_load 0 inv size=1
Xload_inv[424]_no0 mux_1level_tapbuf_size2[65]->out mux_1level_tapbuf_size2[65]->out_out[14] gvdd_load 0 inv size=1
Xload_inv[425]_no0 mux_1level_tapbuf_size2[65]->out mux_1level_tapbuf_size2[65]->out_out[15] gvdd_load 0 inv size=1
Xload_inv[426]_no0 mux_1level_tapbuf_size2[65]->out mux_1level_tapbuf_size2[65]->out_out[16] gvdd_load 0 inv size=1
Xload_inv[427]_no0 mux_1level_tapbuf_size2[65]->out mux_1level_tapbuf_size2[65]->out_out[17] gvdd_load 0 inv size=1
Xload_inv[428]_no0 mux_1level_tapbuf_size2[65]->out mux_1level_tapbuf_size2[65]->out_out[18] gvdd_load 0 inv size=1
Xload_inv[429]_no0 mux_1level_tapbuf_size2[65]->out mux_1level_tapbuf_size2[65]->out_out[19] gvdd_load 0 inv size=1
Xload_inv[430]_no0 mux_1level_tapbuf_size2[65]->out mux_1level_tapbuf_size2[65]->out_out[20] gvdd_load 0 inv size=1
Xload_inv[431]_no0 mux_1level_tapbuf_size2[65]->out mux_1level_tapbuf_size2[65]->out_out[21] gvdd_load 0 inv size=1
Xload_inv[432]_no0 mux_1level_tapbuf_size2[65]->out mux_1level_tapbuf_size2[65]->out_out[22] gvdd_load 0 inv size=1
Xload_inv[433]_no0 mux_1level_tapbuf_size2[65]->out mux_1level_tapbuf_size2[65]->out_out[23] gvdd_load 0 inv size=1
Xload_inv[434]_no0 mux_1level_tapbuf_size2[65]->out mux_1level_tapbuf_size2[65]->out_out[24] gvdd_load 0 inv size=1
Xload_inv[435]_no0 mux_1level_tapbuf_size2[65]->out mux_1level_tapbuf_size2[65]->out_out[25] gvdd_load 0 inv size=1
Xload_inv[436]_no0 mux_1level_tapbuf_size2[65]->out mux_1level_tapbuf_size2[65]->out_out[26] gvdd_load 0 inv size=1
Xload_inv[437]_no0 mux_1level_tapbuf_size2[65]->out mux_1level_tapbuf_size2[65]->out_out[27] gvdd_load 0 inv size=1
Xload_inv[438]_no0 mux_1level_tapbuf_size2[65]->out mux_1level_tapbuf_size2[65]->out_out[28] gvdd_load 0 inv size=1
Xload_inv[439]_no0 mux_1level_tapbuf_size2[65]->out mux_1level_tapbuf_size2[65]->out_out[29] gvdd_load 0 inv size=1
Xload_inv[440]_no0 mux_1level_tapbuf_size2[65]->out mux_1level_tapbuf_size2[65]->out_out[30] gvdd_load 0 inv size=1
Xload_inv[441]_no0 mux_1level_tapbuf_size2[65]->out mux_1level_tapbuf_size2[65]->out_out[31] gvdd_load 0 inv size=1
Xload_inv[442]_no0 mux_1level_tapbuf_size2[65]->out mux_1level_tapbuf_size2[65]->out_out[32] gvdd_load 0 inv size=1
Xload_inv[443]_no0 mux_1level_tapbuf_size2[65]->out mux_1level_tapbuf_size2[65]->out_out[33] gvdd_load 0 inv size=1
Xload_inv[444]_no0 mux_1level_tapbuf_size2[65]->out mux_1level_tapbuf_size2[65]->out_out[34] gvdd_load 0 inv size=1
Xload_inv[445]_no0 mux_1level_tapbuf_size2[65]->out mux_1level_tapbuf_size2[65]->out_out[35] gvdd_load 0 inv size=1
Xload_inv[446]_no0 mux_1level_tapbuf_size2[65]->out mux_1level_tapbuf_size2[65]->out_out[36] gvdd_load 0 inv size=1
Xload_inv[447]_no0 mux_1level_tapbuf_size2[65]->out mux_1level_tapbuf_size2[65]->out_out[37] gvdd_load 0 inv size=1
Xload_inv[448]_no0 mux_1level_tapbuf_size2[65]->out mux_1level_tapbuf_size2[65]->out_out[38] gvdd_load 0 inv size=1
Xload_inv[449]_no0 mux_1level_tapbuf_size2[65]->out mux_1level_tapbuf_size2[65]->out_out[39] gvdd_load 0 inv size=1
Xload_inv[450]_no0 mux_1level_tapbuf_size2[65]->out mux_1level_tapbuf_size2[65]->out_out[40] gvdd_load 0 inv size=1
Xload_inv[451]_no0 mux_1level_tapbuf_size2[65]->out mux_1level_tapbuf_size2[65]->out_out[41] gvdd_load 0 inv size=1
Xload_inv[452]_no0 mux_1level_tapbuf_size2[65]->out mux_1level_tapbuf_size2[65]->out_out[42] gvdd_load 0 inv size=1
Xload_inv[453]_no0 mux_1level_tapbuf_size2[65]->out mux_1level_tapbuf_size2[65]->out_out[43] gvdd_load 0 inv size=1
Xload_inv[454]_no0 mux_1level_tapbuf_size2[65]->out mux_1level_tapbuf_size2[65]->out_out[44] gvdd_load 0 inv size=1
Xload_inv[455]_no0 mux_1level_tapbuf_size2[65]->out mux_1level_tapbuf_size2[65]->out_out[45] gvdd_load 0 inv size=1
Xload_inv[456]_no0 mux_1level_tapbuf_size2[65]->out mux_1level_tapbuf_size2[65]->out_out[46] gvdd_load 0 inv size=1
Xload_inv[457]_no0 mux_1level_tapbuf_size2[65]->out mux_1level_tapbuf_size2[65]->out_out[47] gvdd_load 0 inv size=1
Xload_inv[458]_no0 mux_1level_tapbuf_size2[65]->out mux_1level_tapbuf_size2[65]->out_out[48] gvdd_load 0 inv size=1
Xload_inv[459]_no0 mux_1level_tapbuf_size2[65]->out mux_1level_tapbuf_size2[65]->out_out[49] gvdd_load 0 inv size=1
Xload_inv[460]_no0 mux_1level_tapbuf_size2[65]->out mux_1level_tapbuf_size2[65]->out_out[50] gvdd_load 0 inv size=1
Xload_inv[461]_no0 mux_1level_tapbuf_size2[65]->out mux_1level_tapbuf_size2[65]->out_out[51] gvdd_load 0 inv size=1
Xload_inv[462]_no0 mux_1level_tapbuf_size2[65]->out mux_1level_tapbuf_size2[65]->out_out[52] gvdd_load 0 inv size=1
Xload_inv[463]_no0 mux_1level_tapbuf_size2[65]->out mux_1level_tapbuf_size2[65]->out_out[53] gvdd_load 0 inv size=1
Xload_inv[464]_no0 mux_1level_tapbuf_size2[65]->out mux_1level_tapbuf_size2[65]->out_out[54] gvdd_load 0 inv size=1
Xload_inv[465]_no0 mux_1level_tapbuf_size2[65]->out mux_1level_tapbuf_size2[65]->out_out[55] gvdd_load 0 inv size=1
Xload_inv[466]_no0 mux_1level_tapbuf_size2[65]->out mux_1level_tapbuf_size2[65]->out_out[56] gvdd_load 0 inv size=1
Xload_inv[467]_no0 mux_1level_tapbuf_size2[65]->out mux_1level_tapbuf_size2[65]->out_out[57] gvdd_load 0 inv size=1
Xload_inv[468]_no0 mux_1level_tapbuf_size2[65]->out mux_1level_tapbuf_size2[65]->out_out[58] gvdd_load 0 inv size=1
Xload_inv[469]_no0 mux_1level_tapbuf_size2[65]->out mux_1level_tapbuf_size2[65]->out_out[59] gvdd_load 0 inv size=1
Xload_inv[470]_no0 mux_1level_tapbuf_size2[65]->out load_inv[470]_out gvdd_load 0 inv size=1
Xload_inv[471]_no0 mux_1level_tapbuf_size2[65]->out load_inv[471]_out gvdd_load 0 inv size=1
Xload_inv[472]_no0 mux_1level_tapbuf_size2[65]->out load_inv[472]_out gvdd_load 0 inv size=1
Xload_inv[473]_no0 mux_1level_tapbuf_size2[65]->out load_inv[473]_out gvdd_load 0 inv size=1
Xload_inv[474]_no0 mux_1level_tapbuf_size2[65]->out load_inv[474]_out gvdd_load 0 inv size=1
Xload_inv[475]_no0 mux_1level_tapbuf_size2[65]->out load_inv[475]_out gvdd_load 0 inv size=1
Xload_inv[476]_no0 mux_1level_tapbuf_size2[65]->out load_inv[476]_out gvdd_load 0 inv size=1
Xload_inv[477]_no0 mux_1level_tapbuf_size2[65]->out load_inv[477]_out gvdd_load 0 inv size=1
Xload_inv[478]_no0 mux_1level_tapbuf_size2[65]->out load_inv[478]_out gvdd_load 0 inv size=1
Xload_inv[479]_no0 mux_1level_tapbuf_size2[65]->out load_inv[479]_out gvdd_load 0 inv size=1
.meas tran sum_leakage_power_pb_mux[0to65]
+          param='sum_leakage_power_pb_mux[0to64]+leakage_idle_mux2[65]_out[0]_mux1'
.meas tran sum_energy_per_cycle_pb_mux[0to65]
+          param='sum_energy_per_cycle_pb_mux[0to64]+energy_per_cycle_idle_mux2[65]_out[0]_mux1'
Xmux_1level_tapbuf_size2[66] mux_1level_tapbuf_size2[66]->in[0] mux_1level_tapbuf_size2[66]->in[1] mux_1level_tapbuf_size2[66]->out sram[966]->outb sram[966]->out gvdd_mux_1level_tapbuf_size2[66] 0 mux_1level_tapbuf_size2
***** SRAM bits for MUX[66], level=1, select_path_id=0. *****
*****1*****
Xsram[966] sram->in sram[966]->out sram[966]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[966]->out) 0
.nodeset V(sram[966]->outb) vsp
***** Signal mux_1level_tapbuf_size2[66]->in[0] density = 0.2026, probability=0.5018.*****
Vmux_1level_tapbuf_size2[66]->in[0] mux_1level_tapbuf_size2[66]->in[0] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_1level_tapbuf_size2[66]->in[1] density = 0.2026, probability=0.5018.*****
Vmux_1level_tapbuf_size2[66]->in[1] mux_1level_tapbuf_size2[66]->in[1] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
Vgvdd_mux_1level_tapbuf_size2[66] gvdd_mux_1level_tapbuf_size2[66] 0 vsp
***** Measurements *****
***** Rise delay *****
.meas tran delay_rise_idle_mux2[66]_out[0]_mux1 trig v(mux_1level_tapbuf_size2[66]->in[0]) val='input_thres_pct_rise*vsp' rise=1 td='clock_period'
+          targ v(mux_1level_tapbuf_size2[66]->out) val='output_thres_pct_rise*vsp' rise=1 td='clock_period'
***** Fall delay *****
.meas tran delay_fall_idle_mux2[66]_out[0]_mux1 trig v(mux_1level_tapbuf_size2[66]->in[0]) val='input_thres_pct_fall*vsp' fall=1 td='clock_period'
+          targ v(mux_1level_tapbuf_size2[66]->out) val='output_thres_pct_fall*vsp' fall=1 td='clock_period'
***** Rise timing period *****
.meas start_rise_idle_mux2[66]_out[0]_mux1 when v(mux_1level_tapbuf_size2[66]->in[0])='slew_lower_thres_pct_rise*vsp' rise=1 td='clock_period'
.meas tran switch_rise_idle_mux2[66]_out[0]_mux1 trig v(mux_1level_tapbuf_size2[66]->in[0]) val='slew_lower_thres_pct_rise*vsp' rise=1 td='clock_period'
+          targ v(mux_1level_tapbuf_size2[66]->out) val='slew_upper_thres_pct_rise*vsp' rise=1 td='clock_period'
***** Fall timing period *****
.meas start_fall_idle_mux2[66]_out[0]_mux1 when v(mux_1level_tapbuf_size2[66]->in[0])='slew_lower_thres_pct_fall*vsp' fall=1 td='clock_period'
.meas tran switch_fall_idle_mux2[66]_out[0]_mux1 trig v(mux_1level_tapbuf_size2[66]->in[0]) val='slew_lower_thres_pct_fall*vsp' fall=1 td='clock_period'
+          targ v(mux_1level_tapbuf_size2[66]->out) val='slew_upper_thres_pct_fall*vsp' fall=1 td='clock_period'
***** Leakage Power Measurement *****
.meas tran mux_1level_tapbuf_size2[66]_leakage_power avg p(Vgvdd_mux_1level_tapbuf_size2[66]) from=0 to='clock_period'
.meas tran leakage_idle_mux2[66]_out[0]_mux1 param='mux_1level_tapbuf_size2[66]_leakage_power'
***** Dynamic Power Measurement *****
.meas tran mux_1level_tapbuf_size2[66]_dynamic_power avg p(Vgvdd_mux_1level_tapbuf_size2[66]) from='clock_period' to='6*clock_period'
.meas tran mux_1level_tapbuf_size2[66]_energy_per_cycle param='mux_1level_tapbuf_size2[66]_dynamic_power*clock_period'
.meas tran dynamic_power_idle_mux2[66]_out[0]_mux1  param='mux_1level_tapbuf_size2[66]_dynamic_power'
.meas tran energy_per_cycle_idle_mux2[66]_out[0]_mux1  param='dynamic_power_idle_mux2[66]_out[0]_mux1*clock_period'
.meas tran dynamic_rise_idle_mux2[66]_out[0]_mux1 avg p(Vgvdd_mux_1level_tapbuf_size2[66]) from='start_rise_idle_mux2[66]_out[0]_mux1' to='start_rise_idle_mux2[66]_out[0]_mux1+switch_rise_idle_mux2[66]_out[0]_mux1'
.meas tran dynamic_fall_idle_mux2[66]_out[0]_mux1 avg p(Vgvdd_mux_1level_tapbuf_size2[66]) from='start_fall_idle_mux2[66]_out[0]_mux1' to='start_fall_idle_mux2[66]_out[0]_mux1+switch_fall_idle_mux2[66]_out[0]_mux1'
.meas tran sum_leakage_power_mux[0to66]
+          param='sum_leakage_power_mux[0to65]+leakage_idle_mux2[66]_out[0]_mux1'
.meas tran sum_energy_per_cycle_mux[0to66]
+          param='sum_energy_per_cycle_mux[0to65]+energy_per_cycle_idle_mux2[66]_out[0]_mux1'
Xload_inv[480]_no0 mux_1level_tapbuf_size2[66]->out mux_1level_tapbuf_size2[66]->out_out[0] gvdd_load 0 inv size=1
Xload_inv[481]_no0 mux_1level_tapbuf_size2[66]->out mux_1level_tapbuf_size2[66]->out_out[1] gvdd_load 0 inv size=1
Xload_inv[482]_no0 mux_1level_tapbuf_size2[66]->out mux_1level_tapbuf_size2[66]->out_out[2] gvdd_load 0 inv size=1
Xload_inv[483]_no0 mux_1level_tapbuf_size2[66]->out mux_1level_tapbuf_size2[66]->out_out[3] gvdd_load 0 inv size=1
Xload_inv[484]_no0 mux_1level_tapbuf_size2[66]->out mux_1level_tapbuf_size2[66]->out_out[4] gvdd_load 0 inv size=1
Xload_inv[485]_no0 mux_1level_tapbuf_size2[66]->out mux_1level_tapbuf_size2[66]->out_out[5] gvdd_load 0 inv size=1
Xload_inv[486]_no0 mux_1level_tapbuf_size2[66]->out mux_1level_tapbuf_size2[66]->out_out[6] gvdd_load 0 inv size=1
Xload_inv[487]_no0 mux_1level_tapbuf_size2[66]->out mux_1level_tapbuf_size2[66]->out_out[7] gvdd_load 0 inv size=1
Xload_inv[488]_no0 mux_1level_tapbuf_size2[66]->out mux_1level_tapbuf_size2[66]->out_out[8] gvdd_load 0 inv size=1
Xload_inv[489]_no0 mux_1level_tapbuf_size2[66]->out mux_1level_tapbuf_size2[66]->out_out[9] gvdd_load 0 inv size=1
Xload_inv[490]_no0 mux_1level_tapbuf_size2[66]->out mux_1level_tapbuf_size2[66]->out_out[10] gvdd_load 0 inv size=1
Xload_inv[491]_no0 mux_1level_tapbuf_size2[66]->out mux_1level_tapbuf_size2[66]->out_out[11] gvdd_load 0 inv size=1
Xload_inv[492]_no0 mux_1level_tapbuf_size2[66]->out mux_1level_tapbuf_size2[66]->out_out[12] gvdd_load 0 inv size=1
Xload_inv[493]_no0 mux_1level_tapbuf_size2[66]->out mux_1level_tapbuf_size2[66]->out_out[13] gvdd_load 0 inv size=1
Xload_inv[494]_no0 mux_1level_tapbuf_size2[66]->out mux_1level_tapbuf_size2[66]->out_out[14] gvdd_load 0 inv size=1
Xload_inv[495]_no0 mux_1level_tapbuf_size2[66]->out mux_1level_tapbuf_size2[66]->out_out[15] gvdd_load 0 inv size=1
Xload_inv[496]_no0 mux_1level_tapbuf_size2[66]->out mux_1level_tapbuf_size2[66]->out_out[16] gvdd_load 0 inv size=1
Xload_inv[497]_no0 mux_1level_tapbuf_size2[66]->out mux_1level_tapbuf_size2[66]->out_out[17] gvdd_load 0 inv size=1
Xload_inv[498]_no0 mux_1level_tapbuf_size2[66]->out mux_1level_tapbuf_size2[66]->out_out[18] gvdd_load 0 inv size=1
Xload_inv[499]_no0 mux_1level_tapbuf_size2[66]->out mux_1level_tapbuf_size2[66]->out_out[19] gvdd_load 0 inv size=1
Xload_inv[500]_no0 mux_1level_tapbuf_size2[66]->out mux_1level_tapbuf_size2[66]->out_out[20] gvdd_load 0 inv size=1
Xload_inv[501]_no0 mux_1level_tapbuf_size2[66]->out mux_1level_tapbuf_size2[66]->out_out[21] gvdd_load 0 inv size=1
Xload_inv[502]_no0 mux_1level_tapbuf_size2[66]->out mux_1level_tapbuf_size2[66]->out_out[22] gvdd_load 0 inv size=1
Xload_inv[503]_no0 mux_1level_tapbuf_size2[66]->out mux_1level_tapbuf_size2[66]->out_out[23] gvdd_load 0 inv size=1
Xload_inv[504]_no0 mux_1level_tapbuf_size2[66]->out mux_1level_tapbuf_size2[66]->out_out[24] gvdd_load 0 inv size=1
Xload_inv[505]_no0 mux_1level_tapbuf_size2[66]->out mux_1level_tapbuf_size2[66]->out_out[25] gvdd_load 0 inv size=1
Xload_inv[506]_no0 mux_1level_tapbuf_size2[66]->out mux_1level_tapbuf_size2[66]->out_out[26] gvdd_load 0 inv size=1
Xload_inv[507]_no0 mux_1level_tapbuf_size2[66]->out mux_1level_tapbuf_size2[66]->out_out[27] gvdd_load 0 inv size=1
Xload_inv[508]_no0 mux_1level_tapbuf_size2[66]->out mux_1level_tapbuf_size2[66]->out_out[28] gvdd_load 0 inv size=1
Xload_inv[509]_no0 mux_1level_tapbuf_size2[66]->out mux_1level_tapbuf_size2[66]->out_out[29] gvdd_load 0 inv size=1
Xload_inv[510]_no0 mux_1level_tapbuf_size2[66]->out mux_1level_tapbuf_size2[66]->out_out[30] gvdd_load 0 inv size=1
Xload_inv[511]_no0 mux_1level_tapbuf_size2[66]->out mux_1level_tapbuf_size2[66]->out_out[31] gvdd_load 0 inv size=1
Xload_inv[512]_no0 mux_1level_tapbuf_size2[66]->out mux_1level_tapbuf_size2[66]->out_out[32] gvdd_load 0 inv size=1
Xload_inv[513]_no0 mux_1level_tapbuf_size2[66]->out mux_1level_tapbuf_size2[66]->out_out[33] gvdd_load 0 inv size=1
Xload_inv[514]_no0 mux_1level_tapbuf_size2[66]->out mux_1level_tapbuf_size2[66]->out_out[34] gvdd_load 0 inv size=1
Xload_inv[515]_no0 mux_1level_tapbuf_size2[66]->out mux_1level_tapbuf_size2[66]->out_out[35] gvdd_load 0 inv size=1
Xload_inv[516]_no0 mux_1level_tapbuf_size2[66]->out mux_1level_tapbuf_size2[66]->out_out[36] gvdd_load 0 inv size=1
Xload_inv[517]_no0 mux_1level_tapbuf_size2[66]->out mux_1level_tapbuf_size2[66]->out_out[37] gvdd_load 0 inv size=1
Xload_inv[518]_no0 mux_1level_tapbuf_size2[66]->out mux_1level_tapbuf_size2[66]->out_out[38] gvdd_load 0 inv size=1
Xload_inv[519]_no0 mux_1level_tapbuf_size2[66]->out mux_1level_tapbuf_size2[66]->out_out[39] gvdd_load 0 inv size=1
Xload_inv[520]_no0 mux_1level_tapbuf_size2[66]->out mux_1level_tapbuf_size2[66]->out_out[40] gvdd_load 0 inv size=1
Xload_inv[521]_no0 mux_1level_tapbuf_size2[66]->out mux_1level_tapbuf_size2[66]->out_out[41] gvdd_load 0 inv size=1
Xload_inv[522]_no0 mux_1level_tapbuf_size2[66]->out mux_1level_tapbuf_size2[66]->out_out[42] gvdd_load 0 inv size=1
Xload_inv[523]_no0 mux_1level_tapbuf_size2[66]->out mux_1level_tapbuf_size2[66]->out_out[43] gvdd_load 0 inv size=1
Xload_inv[524]_no0 mux_1level_tapbuf_size2[66]->out mux_1level_tapbuf_size2[66]->out_out[44] gvdd_load 0 inv size=1
Xload_inv[525]_no0 mux_1level_tapbuf_size2[66]->out mux_1level_tapbuf_size2[66]->out_out[45] gvdd_load 0 inv size=1
Xload_inv[526]_no0 mux_1level_tapbuf_size2[66]->out mux_1level_tapbuf_size2[66]->out_out[46] gvdd_load 0 inv size=1
Xload_inv[527]_no0 mux_1level_tapbuf_size2[66]->out mux_1level_tapbuf_size2[66]->out_out[47] gvdd_load 0 inv size=1
Xload_inv[528]_no0 mux_1level_tapbuf_size2[66]->out mux_1level_tapbuf_size2[66]->out_out[48] gvdd_load 0 inv size=1
Xload_inv[529]_no0 mux_1level_tapbuf_size2[66]->out mux_1level_tapbuf_size2[66]->out_out[49] gvdd_load 0 inv size=1
Xload_inv[530]_no0 mux_1level_tapbuf_size2[66]->out mux_1level_tapbuf_size2[66]->out_out[50] gvdd_load 0 inv size=1
Xload_inv[531]_no0 mux_1level_tapbuf_size2[66]->out mux_1level_tapbuf_size2[66]->out_out[51] gvdd_load 0 inv size=1
Xload_inv[532]_no0 mux_1level_tapbuf_size2[66]->out mux_1level_tapbuf_size2[66]->out_out[52] gvdd_load 0 inv size=1
Xload_inv[533]_no0 mux_1level_tapbuf_size2[66]->out mux_1level_tapbuf_size2[66]->out_out[53] gvdd_load 0 inv size=1
Xload_inv[534]_no0 mux_1level_tapbuf_size2[66]->out mux_1level_tapbuf_size2[66]->out_out[54] gvdd_load 0 inv size=1
Xload_inv[535]_no0 mux_1level_tapbuf_size2[66]->out mux_1level_tapbuf_size2[66]->out_out[55] gvdd_load 0 inv size=1
Xload_inv[536]_no0 mux_1level_tapbuf_size2[66]->out mux_1level_tapbuf_size2[66]->out_out[56] gvdd_load 0 inv size=1
Xload_inv[537]_no0 mux_1level_tapbuf_size2[66]->out mux_1level_tapbuf_size2[66]->out_out[57] gvdd_load 0 inv size=1
Xload_inv[538]_no0 mux_1level_tapbuf_size2[66]->out mux_1level_tapbuf_size2[66]->out_out[58] gvdd_load 0 inv size=1
Xload_inv[539]_no0 mux_1level_tapbuf_size2[66]->out mux_1level_tapbuf_size2[66]->out_out[59] gvdd_load 0 inv size=1
Xload_inv[540]_no0 mux_1level_tapbuf_size2[66]->out load_inv[540]_out gvdd_load 0 inv size=1
Xload_inv[541]_no0 mux_1level_tapbuf_size2[66]->out load_inv[541]_out gvdd_load 0 inv size=1
Xload_inv[542]_no0 mux_1level_tapbuf_size2[66]->out load_inv[542]_out gvdd_load 0 inv size=1
Xload_inv[543]_no0 mux_1level_tapbuf_size2[66]->out load_inv[543]_out gvdd_load 0 inv size=1
Xload_inv[544]_no0 mux_1level_tapbuf_size2[66]->out load_inv[544]_out gvdd_load 0 inv size=1
Xload_inv[545]_no0 mux_1level_tapbuf_size2[66]->out load_inv[545]_out gvdd_load 0 inv size=1
Xload_inv[546]_no0 mux_1level_tapbuf_size2[66]->out load_inv[546]_out gvdd_load 0 inv size=1
Xload_inv[547]_no0 mux_1level_tapbuf_size2[66]->out load_inv[547]_out gvdd_load 0 inv size=1
Xload_inv[548]_no0 mux_1level_tapbuf_size2[66]->out load_inv[548]_out gvdd_load 0 inv size=1
Xload_inv[549]_no0 mux_1level_tapbuf_size2[66]->out load_inv[549]_out gvdd_load 0 inv size=1
.meas tran sum_leakage_power_pb_mux[0to66]
+          param='sum_leakage_power_pb_mux[0to65]+leakage_idle_mux2[66]_out[0]_mux1'
.meas tran sum_energy_per_cycle_pb_mux[0to66]
+          param='sum_energy_per_cycle_pb_mux[0to65]+energy_per_cycle_idle_mux2[66]_out[0]_mux1'
Xmux_1level_tapbuf_size2[67] mux_1level_tapbuf_size2[67]->in[0] mux_1level_tapbuf_size2[67]->in[1] mux_1level_tapbuf_size2[67]->out sram[967]->outb sram[967]->out gvdd_mux_1level_tapbuf_size2[67] 0 mux_1level_tapbuf_size2
***** SRAM bits for MUX[67], level=1, select_path_id=0. *****
*****1*****
Xsram[967] sram->in sram[967]->out sram[967]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[967]->out) 0
.nodeset V(sram[967]->outb) vsp
***** Signal mux_1level_tapbuf_size2[67]->in[0] density = 0.2026, probability=0.5018.*****
Vmux_1level_tapbuf_size2[67]->in[0] mux_1level_tapbuf_size2[67]->in[0] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_1level_tapbuf_size2[67]->in[1] density = 0.2026, probability=0.5018.*****
Vmux_1level_tapbuf_size2[67]->in[1] mux_1level_tapbuf_size2[67]->in[1] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
Vgvdd_mux_1level_tapbuf_size2[67] gvdd_mux_1level_tapbuf_size2[67] 0 vsp
***** Measurements *****
***** Rise delay *****
.meas tran delay_rise_idle_mux2[67]_out[0]_mux1 trig v(mux_1level_tapbuf_size2[67]->in[0]) val='input_thres_pct_rise*vsp' rise=1 td='clock_period'
+          targ v(mux_1level_tapbuf_size2[67]->out) val='output_thres_pct_rise*vsp' rise=1 td='clock_period'
***** Fall delay *****
.meas tran delay_fall_idle_mux2[67]_out[0]_mux1 trig v(mux_1level_tapbuf_size2[67]->in[0]) val='input_thres_pct_fall*vsp' fall=1 td='clock_period'
+          targ v(mux_1level_tapbuf_size2[67]->out) val='output_thres_pct_fall*vsp' fall=1 td='clock_period'
***** Rise timing period *****
.meas start_rise_idle_mux2[67]_out[0]_mux1 when v(mux_1level_tapbuf_size2[67]->in[0])='slew_lower_thres_pct_rise*vsp' rise=1 td='clock_period'
.meas tran switch_rise_idle_mux2[67]_out[0]_mux1 trig v(mux_1level_tapbuf_size2[67]->in[0]) val='slew_lower_thres_pct_rise*vsp' rise=1 td='clock_period'
+          targ v(mux_1level_tapbuf_size2[67]->out) val='slew_upper_thres_pct_rise*vsp' rise=1 td='clock_period'
***** Fall timing period *****
.meas start_fall_idle_mux2[67]_out[0]_mux1 when v(mux_1level_tapbuf_size2[67]->in[0])='slew_lower_thres_pct_fall*vsp' fall=1 td='clock_period'
.meas tran switch_fall_idle_mux2[67]_out[0]_mux1 trig v(mux_1level_tapbuf_size2[67]->in[0]) val='slew_lower_thres_pct_fall*vsp' fall=1 td='clock_period'
+          targ v(mux_1level_tapbuf_size2[67]->out) val='slew_upper_thres_pct_fall*vsp' fall=1 td='clock_period'
***** Leakage Power Measurement *****
.meas tran mux_1level_tapbuf_size2[67]_leakage_power avg p(Vgvdd_mux_1level_tapbuf_size2[67]) from=0 to='clock_period'
.meas tran leakage_idle_mux2[67]_out[0]_mux1 param='mux_1level_tapbuf_size2[67]_leakage_power'
***** Dynamic Power Measurement *****
.meas tran mux_1level_tapbuf_size2[67]_dynamic_power avg p(Vgvdd_mux_1level_tapbuf_size2[67]) from='clock_period' to='6*clock_period'
.meas tran mux_1level_tapbuf_size2[67]_energy_per_cycle param='mux_1level_tapbuf_size2[67]_dynamic_power*clock_period'
.meas tran dynamic_power_idle_mux2[67]_out[0]_mux1  param='mux_1level_tapbuf_size2[67]_dynamic_power'
.meas tran energy_per_cycle_idle_mux2[67]_out[0]_mux1  param='dynamic_power_idle_mux2[67]_out[0]_mux1*clock_period'
.meas tran dynamic_rise_idle_mux2[67]_out[0]_mux1 avg p(Vgvdd_mux_1level_tapbuf_size2[67]) from='start_rise_idle_mux2[67]_out[0]_mux1' to='start_rise_idle_mux2[67]_out[0]_mux1+switch_rise_idle_mux2[67]_out[0]_mux1'
.meas tran dynamic_fall_idle_mux2[67]_out[0]_mux1 avg p(Vgvdd_mux_1level_tapbuf_size2[67]) from='start_fall_idle_mux2[67]_out[0]_mux1' to='start_fall_idle_mux2[67]_out[0]_mux1+switch_fall_idle_mux2[67]_out[0]_mux1'
.meas tran sum_leakage_power_mux[0to67]
+          param='sum_leakage_power_mux[0to66]+leakage_idle_mux2[67]_out[0]_mux1'
.meas tran sum_energy_per_cycle_mux[0to67]
+          param='sum_energy_per_cycle_mux[0to66]+energy_per_cycle_idle_mux2[67]_out[0]_mux1'
Xload_inv[550]_no0 mux_1level_tapbuf_size2[67]->out mux_1level_tapbuf_size2[67]->out_out[0] gvdd_load 0 inv size=1
Xload_inv[551]_no0 mux_1level_tapbuf_size2[67]->out mux_1level_tapbuf_size2[67]->out_out[1] gvdd_load 0 inv size=1
Xload_inv[552]_no0 mux_1level_tapbuf_size2[67]->out mux_1level_tapbuf_size2[67]->out_out[2] gvdd_load 0 inv size=1
Xload_inv[553]_no0 mux_1level_tapbuf_size2[67]->out mux_1level_tapbuf_size2[67]->out_out[3] gvdd_load 0 inv size=1
Xload_inv[554]_no0 mux_1level_tapbuf_size2[67]->out mux_1level_tapbuf_size2[67]->out_out[4] gvdd_load 0 inv size=1
Xload_inv[555]_no0 mux_1level_tapbuf_size2[67]->out mux_1level_tapbuf_size2[67]->out_out[5] gvdd_load 0 inv size=1
Xload_inv[556]_no0 mux_1level_tapbuf_size2[67]->out mux_1level_tapbuf_size2[67]->out_out[6] gvdd_load 0 inv size=1
Xload_inv[557]_no0 mux_1level_tapbuf_size2[67]->out mux_1level_tapbuf_size2[67]->out_out[7] gvdd_load 0 inv size=1
Xload_inv[558]_no0 mux_1level_tapbuf_size2[67]->out mux_1level_tapbuf_size2[67]->out_out[8] gvdd_load 0 inv size=1
Xload_inv[559]_no0 mux_1level_tapbuf_size2[67]->out mux_1level_tapbuf_size2[67]->out_out[9] gvdd_load 0 inv size=1
Xload_inv[560]_no0 mux_1level_tapbuf_size2[67]->out mux_1level_tapbuf_size2[67]->out_out[10] gvdd_load 0 inv size=1
Xload_inv[561]_no0 mux_1level_tapbuf_size2[67]->out mux_1level_tapbuf_size2[67]->out_out[11] gvdd_load 0 inv size=1
Xload_inv[562]_no0 mux_1level_tapbuf_size2[67]->out mux_1level_tapbuf_size2[67]->out_out[12] gvdd_load 0 inv size=1
Xload_inv[563]_no0 mux_1level_tapbuf_size2[67]->out mux_1level_tapbuf_size2[67]->out_out[13] gvdd_load 0 inv size=1
Xload_inv[564]_no0 mux_1level_tapbuf_size2[67]->out mux_1level_tapbuf_size2[67]->out_out[14] gvdd_load 0 inv size=1
Xload_inv[565]_no0 mux_1level_tapbuf_size2[67]->out mux_1level_tapbuf_size2[67]->out_out[15] gvdd_load 0 inv size=1
Xload_inv[566]_no0 mux_1level_tapbuf_size2[67]->out mux_1level_tapbuf_size2[67]->out_out[16] gvdd_load 0 inv size=1
Xload_inv[567]_no0 mux_1level_tapbuf_size2[67]->out mux_1level_tapbuf_size2[67]->out_out[17] gvdd_load 0 inv size=1
Xload_inv[568]_no0 mux_1level_tapbuf_size2[67]->out mux_1level_tapbuf_size2[67]->out_out[18] gvdd_load 0 inv size=1
Xload_inv[569]_no0 mux_1level_tapbuf_size2[67]->out mux_1level_tapbuf_size2[67]->out_out[19] gvdd_load 0 inv size=1
Xload_inv[570]_no0 mux_1level_tapbuf_size2[67]->out mux_1level_tapbuf_size2[67]->out_out[20] gvdd_load 0 inv size=1
Xload_inv[571]_no0 mux_1level_tapbuf_size2[67]->out mux_1level_tapbuf_size2[67]->out_out[21] gvdd_load 0 inv size=1
Xload_inv[572]_no0 mux_1level_tapbuf_size2[67]->out mux_1level_tapbuf_size2[67]->out_out[22] gvdd_load 0 inv size=1
Xload_inv[573]_no0 mux_1level_tapbuf_size2[67]->out mux_1level_tapbuf_size2[67]->out_out[23] gvdd_load 0 inv size=1
Xload_inv[574]_no0 mux_1level_tapbuf_size2[67]->out mux_1level_tapbuf_size2[67]->out_out[24] gvdd_load 0 inv size=1
Xload_inv[575]_no0 mux_1level_tapbuf_size2[67]->out mux_1level_tapbuf_size2[67]->out_out[25] gvdd_load 0 inv size=1
Xload_inv[576]_no0 mux_1level_tapbuf_size2[67]->out mux_1level_tapbuf_size2[67]->out_out[26] gvdd_load 0 inv size=1
Xload_inv[577]_no0 mux_1level_tapbuf_size2[67]->out mux_1level_tapbuf_size2[67]->out_out[27] gvdd_load 0 inv size=1
Xload_inv[578]_no0 mux_1level_tapbuf_size2[67]->out mux_1level_tapbuf_size2[67]->out_out[28] gvdd_load 0 inv size=1
Xload_inv[579]_no0 mux_1level_tapbuf_size2[67]->out mux_1level_tapbuf_size2[67]->out_out[29] gvdd_load 0 inv size=1
Xload_inv[580]_no0 mux_1level_tapbuf_size2[67]->out mux_1level_tapbuf_size2[67]->out_out[30] gvdd_load 0 inv size=1
Xload_inv[581]_no0 mux_1level_tapbuf_size2[67]->out mux_1level_tapbuf_size2[67]->out_out[31] gvdd_load 0 inv size=1
Xload_inv[582]_no0 mux_1level_tapbuf_size2[67]->out mux_1level_tapbuf_size2[67]->out_out[32] gvdd_load 0 inv size=1
Xload_inv[583]_no0 mux_1level_tapbuf_size2[67]->out mux_1level_tapbuf_size2[67]->out_out[33] gvdd_load 0 inv size=1
Xload_inv[584]_no0 mux_1level_tapbuf_size2[67]->out mux_1level_tapbuf_size2[67]->out_out[34] gvdd_load 0 inv size=1
Xload_inv[585]_no0 mux_1level_tapbuf_size2[67]->out mux_1level_tapbuf_size2[67]->out_out[35] gvdd_load 0 inv size=1
Xload_inv[586]_no0 mux_1level_tapbuf_size2[67]->out mux_1level_tapbuf_size2[67]->out_out[36] gvdd_load 0 inv size=1
Xload_inv[587]_no0 mux_1level_tapbuf_size2[67]->out mux_1level_tapbuf_size2[67]->out_out[37] gvdd_load 0 inv size=1
Xload_inv[588]_no0 mux_1level_tapbuf_size2[67]->out mux_1level_tapbuf_size2[67]->out_out[38] gvdd_load 0 inv size=1
Xload_inv[589]_no0 mux_1level_tapbuf_size2[67]->out mux_1level_tapbuf_size2[67]->out_out[39] gvdd_load 0 inv size=1
Xload_inv[590]_no0 mux_1level_tapbuf_size2[67]->out mux_1level_tapbuf_size2[67]->out_out[40] gvdd_load 0 inv size=1
Xload_inv[591]_no0 mux_1level_tapbuf_size2[67]->out mux_1level_tapbuf_size2[67]->out_out[41] gvdd_load 0 inv size=1
Xload_inv[592]_no0 mux_1level_tapbuf_size2[67]->out mux_1level_tapbuf_size2[67]->out_out[42] gvdd_load 0 inv size=1
Xload_inv[593]_no0 mux_1level_tapbuf_size2[67]->out mux_1level_tapbuf_size2[67]->out_out[43] gvdd_load 0 inv size=1
Xload_inv[594]_no0 mux_1level_tapbuf_size2[67]->out mux_1level_tapbuf_size2[67]->out_out[44] gvdd_load 0 inv size=1
Xload_inv[595]_no0 mux_1level_tapbuf_size2[67]->out mux_1level_tapbuf_size2[67]->out_out[45] gvdd_load 0 inv size=1
Xload_inv[596]_no0 mux_1level_tapbuf_size2[67]->out mux_1level_tapbuf_size2[67]->out_out[46] gvdd_load 0 inv size=1
Xload_inv[597]_no0 mux_1level_tapbuf_size2[67]->out mux_1level_tapbuf_size2[67]->out_out[47] gvdd_load 0 inv size=1
Xload_inv[598]_no0 mux_1level_tapbuf_size2[67]->out mux_1level_tapbuf_size2[67]->out_out[48] gvdd_load 0 inv size=1
Xload_inv[599]_no0 mux_1level_tapbuf_size2[67]->out mux_1level_tapbuf_size2[67]->out_out[49] gvdd_load 0 inv size=1
Xload_inv[600]_no0 mux_1level_tapbuf_size2[67]->out mux_1level_tapbuf_size2[67]->out_out[50] gvdd_load 0 inv size=1
Xload_inv[601]_no0 mux_1level_tapbuf_size2[67]->out mux_1level_tapbuf_size2[67]->out_out[51] gvdd_load 0 inv size=1
Xload_inv[602]_no0 mux_1level_tapbuf_size2[67]->out mux_1level_tapbuf_size2[67]->out_out[52] gvdd_load 0 inv size=1
Xload_inv[603]_no0 mux_1level_tapbuf_size2[67]->out mux_1level_tapbuf_size2[67]->out_out[53] gvdd_load 0 inv size=1
Xload_inv[604]_no0 mux_1level_tapbuf_size2[67]->out mux_1level_tapbuf_size2[67]->out_out[54] gvdd_load 0 inv size=1
Xload_inv[605]_no0 mux_1level_tapbuf_size2[67]->out mux_1level_tapbuf_size2[67]->out_out[55] gvdd_load 0 inv size=1
Xload_inv[606]_no0 mux_1level_tapbuf_size2[67]->out mux_1level_tapbuf_size2[67]->out_out[56] gvdd_load 0 inv size=1
Xload_inv[607]_no0 mux_1level_tapbuf_size2[67]->out mux_1level_tapbuf_size2[67]->out_out[57] gvdd_load 0 inv size=1
Xload_inv[608]_no0 mux_1level_tapbuf_size2[67]->out mux_1level_tapbuf_size2[67]->out_out[58] gvdd_load 0 inv size=1
Xload_inv[609]_no0 mux_1level_tapbuf_size2[67]->out mux_1level_tapbuf_size2[67]->out_out[59] gvdd_load 0 inv size=1
Xload_inv[610]_no0 mux_1level_tapbuf_size2[67]->out load_inv[610]_out gvdd_load 0 inv size=1
Xload_inv[611]_no0 mux_1level_tapbuf_size2[67]->out load_inv[611]_out gvdd_load 0 inv size=1
Xload_inv[612]_no0 mux_1level_tapbuf_size2[67]->out load_inv[612]_out gvdd_load 0 inv size=1
Xload_inv[613]_no0 mux_1level_tapbuf_size2[67]->out load_inv[613]_out gvdd_load 0 inv size=1
Xload_inv[614]_no0 mux_1level_tapbuf_size2[67]->out load_inv[614]_out gvdd_load 0 inv size=1
Xload_inv[615]_no0 mux_1level_tapbuf_size2[67]->out load_inv[615]_out gvdd_load 0 inv size=1
Xload_inv[616]_no0 mux_1level_tapbuf_size2[67]->out load_inv[616]_out gvdd_load 0 inv size=1
Xload_inv[617]_no0 mux_1level_tapbuf_size2[67]->out load_inv[617]_out gvdd_load 0 inv size=1
Xload_inv[618]_no0 mux_1level_tapbuf_size2[67]->out load_inv[618]_out gvdd_load 0 inv size=1
Xload_inv[619]_no0 mux_1level_tapbuf_size2[67]->out load_inv[619]_out gvdd_load 0 inv size=1
.meas tran sum_leakage_power_pb_mux[0to67]
+          param='sum_leakage_power_pb_mux[0to66]+leakage_idle_mux2[67]_out[0]_mux1'
.meas tran sum_energy_per_cycle_pb_mux[0to67]
+          param='sum_energy_per_cycle_pb_mux[0to66]+energy_per_cycle_idle_mux2[67]_out[0]_mux1'
Xmux_1level_tapbuf_size2[68] mux_1level_tapbuf_size2[68]->in[0] mux_1level_tapbuf_size2[68]->in[1] mux_1level_tapbuf_size2[68]->out sram[968]->outb sram[968]->out gvdd_mux_1level_tapbuf_size2[68] 0 mux_1level_tapbuf_size2
***** SRAM bits for MUX[68], level=1, select_path_id=0. *****
*****1*****
Xsram[968] sram->in sram[968]->out sram[968]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[968]->out) 0
.nodeset V(sram[968]->outb) vsp
***** Signal mux_1level_tapbuf_size2[68]->in[0] density = 0.2026, probability=0.5018.*****
Vmux_1level_tapbuf_size2[68]->in[0] mux_1level_tapbuf_size2[68]->in[0] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_1level_tapbuf_size2[68]->in[1] density = 0.2026, probability=0.5018.*****
Vmux_1level_tapbuf_size2[68]->in[1] mux_1level_tapbuf_size2[68]->in[1] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.5018*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
Vgvdd_mux_1level_tapbuf_size2[68] gvdd_mux_1level_tapbuf_size2[68] 0 vsp
***** Measurements *****
***** Rise delay *****
.meas tran delay_rise_idle_mux2[68]_out[0]_mux1 trig v(mux_1level_tapbuf_size2[68]->in[0]) val='input_thres_pct_rise*vsp' rise=1 td='clock_period'
+          targ v(mux_1level_tapbuf_size2[68]->out) val='output_thres_pct_rise*vsp' rise=1 td='clock_period'
***** Fall delay *****
.meas tran delay_fall_idle_mux2[68]_out[0]_mux1 trig v(mux_1level_tapbuf_size2[68]->in[0]) val='input_thres_pct_fall*vsp' fall=1 td='clock_period'
+          targ v(mux_1level_tapbuf_size2[68]->out) val='output_thres_pct_fall*vsp' fall=1 td='clock_period'
***** Rise timing period *****
.meas start_rise_idle_mux2[68]_out[0]_mux1 when v(mux_1level_tapbuf_size2[68]->in[0])='slew_lower_thres_pct_rise*vsp' rise=1 td='clock_period'
.meas tran switch_rise_idle_mux2[68]_out[0]_mux1 trig v(mux_1level_tapbuf_size2[68]->in[0]) val='slew_lower_thres_pct_rise*vsp' rise=1 td='clock_period'
+          targ v(mux_1level_tapbuf_size2[68]->out) val='slew_upper_thres_pct_rise*vsp' rise=1 td='clock_period'
***** Fall timing period *****
.meas start_fall_idle_mux2[68]_out[0]_mux1 when v(mux_1level_tapbuf_size2[68]->in[0])='slew_lower_thres_pct_fall*vsp' fall=1 td='clock_period'
.meas tran switch_fall_idle_mux2[68]_out[0]_mux1 trig v(mux_1level_tapbuf_size2[68]->in[0]) val='slew_lower_thres_pct_fall*vsp' fall=1 td='clock_period'
+          targ v(mux_1level_tapbuf_size2[68]->out) val='slew_upper_thres_pct_fall*vsp' fall=1 td='clock_period'
***** Leakage Power Measurement *****
.meas tran mux_1level_tapbuf_size2[68]_leakage_power avg p(Vgvdd_mux_1level_tapbuf_size2[68]) from=0 to='clock_period'
.meas tran leakage_idle_mux2[68]_out[0]_mux1 param='mux_1level_tapbuf_size2[68]_leakage_power'
***** Dynamic Power Measurement *****
.meas tran mux_1level_tapbuf_size2[68]_dynamic_power avg p(Vgvdd_mux_1level_tapbuf_size2[68]) from='clock_period' to='6*clock_period'
.meas tran mux_1level_tapbuf_size2[68]_energy_per_cycle param='mux_1level_tapbuf_size2[68]_dynamic_power*clock_period'
.meas tran dynamic_power_idle_mux2[68]_out[0]_mux1  param='mux_1level_tapbuf_size2[68]_dynamic_power'
.meas tran energy_per_cycle_idle_mux2[68]_out[0]_mux1  param='dynamic_power_idle_mux2[68]_out[0]_mux1*clock_period'
.meas tran dynamic_rise_idle_mux2[68]_out[0]_mux1 avg p(Vgvdd_mux_1level_tapbuf_size2[68]) from='start_rise_idle_mux2[68]_out[0]_mux1' to='start_rise_idle_mux2[68]_out[0]_mux1+switch_rise_idle_mux2[68]_out[0]_mux1'
.meas tran dynamic_fall_idle_mux2[68]_out[0]_mux1 avg p(Vgvdd_mux_1level_tapbuf_size2[68]) from='start_fall_idle_mux2[68]_out[0]_mux1' to='start_fall_idle_mux2[68]_out[0]_mux1+switch_fall_idle_mux2[68]_out[0]_mux1'
.meas tran sum_leakage_power_mux[0to68]
+          param='sum_leakage_power_mux[0to67]+leakage_idle_mux2[68]_out[0]_mux1'
.meas tran sum_energy_per_cycle_mux[0to68]
+          param='sum_energy_per_cycle_mux[0to67]+energy_per_cycle_idle_mux2[68]_out[0]_mux1'
Xload_inv[620]_no0 mux_1level_tapbuf_size2[68]->out mux_1level_tapbuf_size2[68]->out_out[0] gvdd_load 0 inv size=1
Xload_inv[621]_no0 mux_1level_tapbuf_size2[68]->out mux_1level_tapbuf_size2[68]->out_out[1] gvdd_load 0 inv size=1
Xload_inv[622]_no0 mux_1level_tapbuf_size2[68]->out mux_1level_tapbuf_size2[68]->out_out[2] gvdd_load 0 inv size=1
Xload_inv[623]_no0 mux_1level_tapbuf_size2[68]->out mux_1level_tapbuf_size2[68]->out_out[3] gvdd_load 0 inv size=1
Xload_inv[624]_no0 mux_1level_tapbuf_size2[68]->out mux_1level_tapbuf_size2[68]->out_out[4] gvdd_load 0 inv size=1
Xload_inv[625]_no0 mux_1level_tapbuf_size2[68]->out mux_1level_tapbuf_size2[68]->out_out[5] gvdd_load 0 inv size=1
Xload_inv[626]_no0 mux_1level_tapbuf_size2[68]->out mux_1level_tapbuf_size2[68]->out_out[6] gvdd_load 0 inv size=1
Xload_inv[627]_no0 mux_1level_tapbuf_size2[68]->out mux_1level_tapbuf_size2[68]->out_out[7] gvdd_load 0 inv size=1
Xload_inv[628]_no0 mux_1level_tapbuf_size2[68]->out mux_1level_tapbuf_size2[68]->out_out[8] gvdd_load 0 inv size=1
Xload_inv[629]_no0 mux_1level_tapbuf_size2[68]->out mux_1level_tapbuf_size2[68]->out_out[9] gvdd_load 0 inv size=1
Xload_inv[630]_no0 mux_1level_tapbuf_size2[68]->out mux_1level_tapbuf_size2[68]->out_out[10] gvdd_load 0 inv size=1
Xload_inv[631]_no0 mux_1level_tapbuf_size2[68]->out mux_1level_tapbuf_size2[68]->out_out[11] gvdd_load 0 inv size=1
Xload_inv[632]_no0 mux_1level_tapbuf_size2[68]->out mux_1level_tapbuf_size2[68]->out_out[12] gvdd_load 0 inv size=1
Xload_inv[633]_no0 mux_1level_tapbuf_size2[68]->out mux_1level_tapbuf_size2[68]->out_out[13] gvdd_load 0 inv size=1
Xload_inv[634]_no0 mux_1level_tapbuf_size2[68]->out mux_1level_tapbuf_size2[68]->out_out[14] gvdd_load 0 inv size=1
Xload_inv[635]_no0 mux_1level_tapbuf_size2[68]->out mux_1level_tapbuf_size2[68]->out_out[15] gvdd_load 0 inv size=1
Xload_inv[636]_no0 mux_1level_tapbuf_size2[68]->out mux_1level_tapbuf_size2[68]->out_out[16] gvdd_load 0 inv size=1
Xload_inv[637]_no0 mux_1level_tapbuf_size2[68]->out mux_1level_tapbuf_size2[68]->out_out[17] gvdd_load 0 inv size=1
Xload_inv[638]_no0 mux_1level_tapbuf_size2[68]->out mux_1level_tapbuf_size2[68]->out_out[18] gvdd_load 0 inv size=1
Xload_inv[639]_no0 mux_1level_tapbuf_size2[68]->out mux_1level_tapbuf_size2[68]->out_out[19] gvdd_load 0 inv size=1
Xload_inv[640]_no0 mux_1level_tapbuf_size2[68]->out mux_1level_tapbuf_size2[68]->out_out[20] gvdd_load 0 inv size=1
Xload_inv[641]_no0 mux_1level_tapbuf_size2[68]->out mux_1level_tapbuf_size2[68]->out_out[21] gvdd_load 0 inv size=1
Xload_inv[642]_no0 mux_1level_tapbuf_size2[68]->out mux_1level_tapbuf_size2[68]->out_out[22] gvdd_load 0 inv size=1
Xload_inv[643]_no0 mux_1level_tapbuf_size2[68]->out mux_1level_tapbuf_size2[68]->out_out[23] gvdd_load 0 inv size=1
Xload_inv[644]_no0 mux_1level_tapbuf_size2[68]->out mux_1level_tapbuf_size2[68]->out_out[24] gvdd_load 0 inv size=1
Xload_inv[645]_no0 mux_1level_tapbuf_size2[68]->out mux_1level_tapbuf_size2[68]->out_out[25] gvdd_load 0 inv size=1
Xload_inv[646]_no0 mux_1level_tapbuf_size2[68]->out mux_1level_tapbuf_size2[68]->out_out[26] gvdd_load 0 inv size=1
Xload_inv[647]_no0 mux_1level_tapbuf_size2[68]->out mux_1level_tapbuf_size2[68]->out_out[27] gvdd_load 0 inv size=1
Xload_inv[648]_no0 mux_1level_tapbuf_size2[68]->out mux_1level_tapbuf_size2[68]->out_out[28] gvdd_load 0 inv size=1
Xload_inv[649]_no0 mux_1level_tapbuf_size2[68]->out mux_1level_tapbuf_size2[68]->out_out[29] gvdd_load 0 inv size=1
Xload_inv[650]_no0 mux_1level_tapbuf_size2[68]->out mux_1level_tapbuf_size2[68]->out_out[30] gvdd_load 0 inv size=1
Xload_inv[651]_no0 mux_1level_tapbuf_size2[68]->out mux_1level_tapbuf_size2[68]->out_out[31] gvdd_load 0 inv size=1
Xload_inv[652]_no0 mux_1level_tapbuf_size2[68]->out mux_1level_tapbuf_size2[68]->out_out[32] gvdd_load 0 inv size=1
Xload_inv[653]_no0 mux_1level_tapbuf_size2[68]->out mux_1level_tapbuf_size2[68]->out_out[33] gvdd_load 0 inv size=1
Xload_inv[654]_no0 mux_1level_tapbuf_size2[68]->out mux_1level_tapbuf_size2[68]->out_out[34] gvdd_load 0 inv size=1
Xload_inv[655]_no0 mux_1level_tapbuf_size2[68]->out mux_1level_tapbuf_size2[68]->out_out[35] gvdd_load 0 inv size=1
Xload_inv[656]_no0 mux_1level_tapbuf_size2[68]->out mux_1level_tapbuf_size2[68]->out_out[36] gvdd_load 0 inv size=1
Xload_inv[657]_no0 mux_1level_tapbuf_size2[68]->out mux_1level_tapbuf_size2[68]->out_out[37] gvdd_load 0 inv size=1
Xload_inv[658]_no0 mux_1level_tapbuf_size2[68]->out mux_1level_tapbuf_size2[68]->out_out[38] gvdd_load 0 inv size=1
Xload_inv[659]_no0 mux_1level_tapbuf_size2[68]->out mux_1level_tapbuf_size2[68]->out_out[39] gvdd_load 0 inv size=1
Xload_inv[660]_no0 mux_1level_tapbuf_size2[68]->out mux_1level_tapbuf_size2[68]->out_out[40] gvdd_load 0 inv size=1
Xload_inv[661]_no0 mux_1level_tapbuf_size2[68]->out mux_1level_tapbuf_size2[68]->out_out[41] gvdd_load 0 inv size=1
Xload_inv[662]_no0 mux_1level_tapbuf_size2[68]->out mux_1level_tapbuf_size2[68]->out_out[42] gvdd_load 0 inv size=1
Xload_inv[663]_no0 mux_1level_tapbuf_size2[68]->out mux_1level_tapbuf_size2[68]->out_out[43] gvdd_load 0 inv size=1
Xload_inv[664]_no0 mux_1level_tapbuf_size2[68]->out mux_1level_tapbuf_size2[68]->out_out[44] gvdd_load 0 inv size=1
Xload_inv[665]_no0 mux_1level_tapbuf_size2[68]->out mux_1level_tapbuf_size2[68]->out_out[45] gvdd_load 0 inv size=1
Xload_inv[666]_no0 mux_1level_tapbuf_size2[68]->out mux_1level_tapbuf_size2[68]->out_out[46] gvdd_load 0 inv size=1
Xload_inv[667]_no0 mux_1level_tapbuf_size2[68]->out mux_1level_tapbuf_size2[68]->out_out[47] gvdd_load 0 inv size=1
Xload_inv[668]_no0 mux_1level_tapbuf_size2[68]->out mux_1level_tapbuf_size2[68]->out_out[48] gvdd_load 0 inv size=1
Xload_inv[669]_no0 mux_1level_tapbuf_size2[68]->out mux_1level_tapbuf_size2[68]->out_out[49] gvdd_load 0 inv size=1
Xload_inv[670]_no0 mux_1level_tapbuf_size2[68]->out mux_1level_tapbuf_size2[68]->out_out[50] gvdd_load 0 inv size=1
Xload_inv[671]_no0 mux_1level_tapbuf_size2[68]->out mux_1level_tapbuf_size2[68]->out_out[51] gvdd_load 0 inv size=1
Xload_inv[672]_no0 mux_1level_tapbuf_size2[68]->out mux_1level_tapbuf_size2[68]->out_out[52] gvdd_load 0 inv size=1
Xload_inv[673]_no0 mux_1level_tapbuf_size2[68]->out mux_1level_tapbuf_size2[68]->out_out[53] gvdd_load 0 inv size=1
Xload_inv[674]_no0 mux_1level_tapbuf_size2[68]->out mux_1level_tapbuf_size2[68]->out_out[54] gvdd_load 0 inv size=1
Xload_inv[675]_no0 mux_1level_tapbuf_size2[68]->out mux_1level_tapbuf_size2[68]->out_out[55] gvdd_load 0 inv size=1
Xload_inv[676]_no0 mux_1level_tapbuf_size2[68]->out mux_1level_tapbuf_size2[68]->out_out[56] gvdd_load 0 inv size=1
Xload_inv[677]_no0 mux_1level_tapbuf_size2[68]->out mux_1level_tapbuf_size2[68]->out_out[57] gvdd_load 0 inv size=1
Xload_inv[678]_no0 mux_1level_tapbuf_size2[68]->out mux_1level_tapbuf_size2[68]->out_out[58] gvdd_load 0 inv size=1
Xload_inv[679]_no0 mux_1level_tapbuf_size2[68]->out mux_1level_tapbuf_size2[68]->out_out[59] gvdd_load 0 inv size=1
Xload_inv[680]_no0 mux_1level_tapbuf_size2[68]->out load_inv[680]_out gvdd_load 0 inv size=1
Xload_inv[681]_no0 mux_1level_tapbuf_size2[68]->out load_inv[681]_out gvdd_load 0 inv size=1
Xload_inv[682]_no0 mux_1level_tapbuf_size2[68]->out load_inv[682]_out gvdd_load 0 inv size=1
Xload_inv[683]_no0 mux_1level_tapbuf_size2[68]->out load_inv[683]_out gvdd_load 0 inv size=1
Xload_inv[684]_no0 mux_1level_tapbuf_size2[68]->out load_inv[684]_out gvdd_load 0 inv size=1
Xload_inv[685]_no0 mux_1level_tapbuf_size2[68]->out load_inv[685]_out gvdd_load 0 inv size=1
Xload_inv[686]_no0 mux_1level_tapbuf_size2[68]->out load_inv[686]_out gvdd_load 0 inv size=1
Xload_inv[687]_no0 mux_1level_tapbuf_size2[68]->out load_inv[687]_out gvdd_load 0 inv size=1
Xload_inv[688]_no0 mux_1level_tapbuf_size2[68]->out load_inv[688]_out gvdd_load 0 inv size=1
Xload_inv[689]_no0 mux_1level_tapbuf_size2[68]->out load_inv[689]_out gvdd_load 0 inv size=1
.meas tran sum_leakage_power_pb_mux[0to68]
+          param='sum_leakage_power_pb_mux[0to67]+leakage_idle_mux2[68]_out[0]_mux1'
.meas tran sum_energy_per_cycle_pb_mux[0to68]
+          param='sum_energy_per_cycle_pb_mux[0to67]+energy_per_cycle_idle_mux2[68]_out[0]_mux1'
Xmux_1level_tapbuf_size2[69] mux_1level_tapbuf_size2[69]->in[0] mux_1level_tapbuf_size2[69]->in[1] mux_1level_tapbuf_size2[69]->out sram[969]->outb sram[969]->out gvdd_mux_1level_tapbuf_size2[69] 0 mux_1level_tapbuf_size2
***** SRAM bits for MUX[69], level=1, select_path_id=0. *****
*****1*****
Xsram[969] sram->in sram[969]->out sram[969]->outb gvdd_sram sgnd  sram6T
.nodeset V(sram[969]->out) 0
.nodeset V(sram[969]->outb) vsp
***** Signal mux_1level_tapbuf_size2[69]->in[0] density = 0.2026, probability=0.4982.*****
Vmux_1level_tapbuf_size2[69]->in[0] mux_1level_tapbuf_size2[69]->in[0] 0
+  pulse(0 vsp 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.4982*9.87167*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '9.87167*clock_period')
***** Signal mux_1level_tapbuf_size2[69]->in[1] density = 0.100935, probability=0.4982.*****
Vmux_1level_tapbuf_size2[69]->in[1] mux_1level_tapbuf_size2[69]->in[1] 0
+  pulse(vsp 0 'clock_period'
+  'input_slew_pct_rise*clock_period' 'input_slew_pct_fall*clock_period'
+  '0.4982*19.8147*(1-input_slew_pct_rise-input_slew_pct_fall)*clock_period' '19.8147*clock_period')
Vgvdd_mux_1level_tapbuf_size2[69] gvdd_mux_1level_tapbuf_size2[69] 0 vsp
***** Measurements *****
***** Rise delay *****
.meas tran delay_rise_grid[1][1]_clb[0]_mode[clb]_fle[9]_mode[n1_lut6]_ble6[0]_mode[ble6]_out[0]_mux1 trig v(mux_1level_tapbuf_size2[69]->in[0]) val='input_thres_pct_rise*vsp' rise=1 td='clock_period'
+          targ v(mux_1level_tapbuf_size2[69]->out) val='output_thres_pct_rise*vsp' rise=1 td='clock_period'
***** Fall delay *****
.meas tran delay_fall_grid[1][1]_clb[0]_mode[clb]_fle[9]_mode[n1_lut6]_ble6[0]_mode[ble6]_out[0]_mux1 trig v(mux_1level_tapbuf_size2[69]->in[0]) val='input_thres_pct_fall*vsp' fall=1 td='clock_period'
+          targ v(mux_1level_tapbuf_size2[69]->out) val='output_thres_pct_fall*vsp' fall=1 td='clock_period'
***** Rise timing period *****
.meas start_rise_grid[1][1]_clb[0]_mode[clb]_fle[9]_mode[n1_lut6]_ble6[0]_mode[ble6]_out[0]_mux1 when v(mux_1level_tapbuf_size2[69]->in[0])='slew_lower_thres_pct_rise*vsp' rise=1 td='clock_period'
.meas tran switch_rise_grid[1][1]_clb[0]_mode[clb]_fle[9]_mode[n1_lut6]_ble6[0]_mode[ble6]_out[0]_mux1 trig v(mux_1level_tapbuf_size2[69]->in[0]) val='slew_lower_thres_pct_rise*vsp' rise=1 td='clock_period'
+          targ v(mux_1level_tapbuf_size2[69]->out) val='slew_upper_thres_pct_rise*vsp' rise=1 td='clock_period'
***** Fall timing period *****
.meas start_fall_grid[1][1]_clb[0]_mode[clb]_fle[9]_mode[n1_lut6]_ble6[0]_mode[ble6]_out[0]_mux1 when v(mux_1level_tapbuf_size2[69]->in[0])='slew_lower_thres_pct_fall*vsp' fall=1 td='clock_period'
.meas tran switch_fall_grid[1][1]_clb[0]_mode[clb]_fle[9]_mode[n1_lut6]_ble6[0]_mode[ble6]_out[0]_mux1 trig v(mux_1level_tapbuf_size2[69]->in[0]) val='slew_lower_thres_pct_fall*vsp' fall=1 td='clock_period'
+          targ v(mux_1level_tapbuf_size2[69]->out) val='slew_upper_thres_pct_fall*vsp' fall=1 td='clock_period'
***** Leakage Power Measurement *****
.meas tran mux_1level_tapbuf_size2[69]_leakage_power avg p(Vgvdd_mux_1level_tapbuf_size2[69]) from=0 to='clock_period'
.meas tran leakage_grid[1][1]_clb[0]_mode[clb]_fle[9]_mode[n1_lut6]_ble6[0]_mode[ble6]_out[0]_mux1 param='mux_1level_tapbuf_size2[69]_leakage_power'
***** Dynamic Power Measurement *****
.meas tran mux_1level_tapbuf_size2[69]_dynamic_power avg p(Vgvdd_mux_1level_tapbuf_size2[69]) from='clock_period' to='6*clock_period'
.meas tran mux_1level_tapbuf_size2[69]_energy_per_cycle param='mux_1level_tapbuf_size2[69]_dynamic_power*clock_period'
.meas tran dynamic_power_grid[1][1]_clb[0]_mode[clb]_fle[9]_mode[n1_lut6]_ble6[0]_mode[ble6]_out[0]_mux1  param='mux_1level_tapbuf_size2[69]_dynamic_power'
.meas tran energy_per_cycle_grid[1][1]_clb[0]_mode[clb]_fle[9]_mode[n1_lut6]_ble6[0]_mode[ble6]_out[0]_mux1  param='dynamic_power_grid[1][1]_clb[0]_mode[clb]_fle[9]_mode[n1_lut6]_ble6[0]_mode[ble6]_out[0]_mux1*clock_period'
.meas tran dynamic_rise_grid[1][1]_clb[0]_mode[clb]_fle[9]_mode[n1_lut6]_ble6[0]_mode[ble6]_out[0]_mux1 avg p(Vgvdd_mux_1level_tapbuf_size2[69]) from='start_rise_grid[1][1]_clb[0]_mode[clb]_fle[9]_mode[n1_lut6]_ble6[0]_mode[ble6]_out[0]_mux1' to='start_rise_grid[1][1]_clb[0]_mode[clb]_fle[9]_mode[n1_lut6]_ble6[0]_mode[ble6]_out[0]_mux1+switch_rise_grid[1][1]_clb[0]_mode[clb]_fle[9]_mode[n1_lut6]_ble6[0]_mode[ble6]_out[0]_mux1'
.meas tran dynamic_fall_grid[1][1]_clb[0]_mode[clb]_fle[9]_mode[n1_lut6]_ble6[0]_mode[ble6]_out[0]_mux1 avg p(Vgvdd_mux_1level_tapbuf_size2[69]) from='start_fall_grid[1][1]_clb[0]_mode[clb]_fle[9]_mode[n1_lut6]_ble6[0]_mode[ble6]_out[0]_mux1' to='start_fall_grid[1][1]_clb[0]_mode[clb]_fle[9]_mode[n1_lut6]_ble6[0]_mode[ble6]_out[0]_mux1+switch_fall_grid[1][1]_clb[0]_mode[clb]_fle[9]_mode[n1_lut6]_ble6[0]_mode[ble6]_out[0]_mux1'
.meas tran sum_leakage_power_mux[0to69]
+          param='sum_leakage_power_mux[0to68]+leakage_grid[1][1]_clb[0]_mode[clb]_fle[9]_mode[n1_lut6]_ble6[0]_mode[ble6]_out[0]_mux1'
.meas tran sum_energy_per_cycle_mux[0to69]
+          param='sum_energy_per_cycle_mux[0to68]+energy_per_cycle_grid[1][1]_clb[0]_mode[clb]_fle[9]_mode[n1_lut6]_ble6[0]_mode[ble6]_out[0]_mux1'
Xload_inv[690]_no0 mux_1level_tapbuf_size2[69]->out mux_1level_tapbuf_size2[69]->out_out[0] gvdd_load 0 inv size=1
Xload_inv[691]_no0 mux_1level_tapbuf_size2[69]->out mux_1level_tapbuf_size2[69]->out_out[1] gvdd_load 0 inv size=1
Xload_inv[692]_no0 mux_1level_tapbuf_size2[69]->out mux_1level_tapbuf_size2[69]->out_out[2] gvdd_load 0 inv size=1
Xload_inv[693]_no0 mux_1level_tapbuf_size2[69]->out mux_1level_tapbuf_size2[69]->out_out[3] gvdd_load 0 inv size=1
Xload_inv[694]_no0 mux_1level_tapbuf_size2[69]->out mux_1level_tapbuf_size2[69]->out_out[4] gvdd_load 0 inv size=1
Xload_inv[695]_no0 mux_1level_tapbuf_size2[69]->out mux_1level_tapbuf_size2[69]->out_out[5] gvdd_load 0 inv size=1
Xload_inv[696]_no0 mux_1level_tapbuf_size2[69]->out mux_1level_tapbuf_size2[69]->out_out[6] gvdd_load 0 inv size=1
Xload_inv[697]_no0 mux_1level_tapbuf_size2[69]->out mux_1level_tapbuf_size2[69]->out_out[7] gvdd_load 0 inv size=1
Xload_inv[698]_no0 mux_1level_tapbuf_size2[69]->out mux_1level_tapbuf_size2[69]->out_out[8] gvdd_load 0 inv size=1
Xload_inv[699]_no0 mux_1level_tapbuf_size2[69]->out mux_1level_tapbuf_size2[69]->out_out[9] gvdd_load 0 inv size=1
Xload_inv[700]_no0 mux_1level_tapbuf_size2[69]->out mux_1level_tapbuf_size2[69]->out_out[10] gvdd_load 0 inv size=1
Xload_inv[701]_no0 mux_1level_tapbuf_size2[69]->out mux_1level_tapbuf_size2[69]->out_out[11] gvdd_load 0 inv size=1
Xload_inv[702]_no0 mux_1level_tapbuf_size2[69]->out mux_1level_tapbuf_size2[69]->out_out[12] gvdd_load 0 inv size=1
Xload_inv[703]_no0 mux_1level_tapbuf_size2[69]->out mux_1level_tapbuf_size2[69]->out_out[13] gvdd_load 0 inv size=1
Xload_inv[704]_no0 mux_1level_tapbuf_size2[69]->out mux_1level_tapbuf_size2[69]->out_out[14] gvdd_load 0 inv size=1
Xload_inv[705]_no0 mux_1level_tapbuf_size2[69]->out mux_1level_tapbuf_size2[69]->out_out[15] gvdd_load 0 inv size=1
Xload_inv[706]_no0 mux_1level_tapbuf_size2[69]->out mux_1level_tapbuf_size2[69]->out_out[16] gvdd_load 0 inv size=1
Xload_inv[707]_no0 mux_1level_tapbuf_size2[69]->out mux_1level_tapbuf_size2[69]->out_out[17] gvdd_load 0 inv size=1
Xload_inv[708]_no0 mux_1level_tapbuf_size2[69]->out mux_1level_tapbuf_size2[69]->out_out[18] gvdd_load 0 inv size=1
Xload_inv[709]_no0 mux_1level_tapbuf_size2[69]->out mux_1level_tapbuf_size2[69]->out_out[19] gvdd_load 0 inv size=1
Xload_inv[710]_no0 mux_1level_tapbuf_size2[69]->out mux_1level_tapbuf_size2[69]->out_out[20] gvdd_load 0 inv size=1
Xload_inv[711]_no0 mux_1level_tapbuf_size2[69]->out mux_1level_tapbuf_size2[69]->out_out[21] gvdd_load 0 inv size=1
Xload_inv[712]_no0 mux_1level_tapbuf_size2[69]->out mux_1level_tapbuf_size2[69]->out_out[22] gvdd_load 0 inv size=1
Xload_inv[713]_no0 mux_1level_tapbuf_size2[69]->out mux_1level_tapbuf_size2[69]->out_out[23] gvdd_load 0 inv size=1
Xload_inv[714]_no0 mux_1level_tapbuf_size2[69]->out mux_1level_tapbuf_size2[69]->out_out[24] gvdd_load 0 inv size=1
Xload_inv[715]_no0 mux_1level_tapbuf_size2[69]->out mux_1level_tapbuf_size2[69]->out_out[25] gvdd_load 0 inv size=1
Xload_inv[716]_no0 mux_1level_tapbuf_size2[69]->out mux_1level_tapbuf_size2[69]->out_out[26] gvdd_load 0 inv size=1
Xload_inv[717]_no0 mux_1level_tapbuf_size2[69]->out mux_1level_tapbuf_size2[69]->out_out[27] gvdd_load 0 inv size=1
Xload_inv[718]_no0 mux_1level_tapbuf_size2[69]->out mux_1level_tapbuf_size2[69]->out_out[28] gvdd_load 0 inv size=1
Xload_inv[719]_no0 mux_1level_tapbuf_size2[69]->out mux_1level_tapbuf_size2[69]->out_out[29] gvdd_load 0 inv size=1
Xload_inv[720]_no0 mux_1level_tapbuf_size2[69]->out mux_1level_tapbuf_size2[69]->out_out[30] gvdd_load 0 inv size=1
Xload_inv[721]_no0 mux_1level_tapbuf_size2[69]->out mux_1level_tapbuf_size2[69]->out_out[31] gvdd_load 0 inv size=1
Xload_inv[722]_no0 mux_1level_tapbuf_size2[69]->out mux_1level_tapbuf_size2[69]->out_out[32] gvdd_load 0 inv size=1
Xload_inv[723]_no0 mux_1level_tapbuf_size2[69]->out mux_1level_tapbuf_size2[69]->out_out[33] gvdd_load 0 inv size=1
Xload_inv[724]_no0 mux_1level_tapbuf_size2[69]->out mux_1level_tapbuf_size2[69]->out_out[34] gvdd_load 0 inv size=1
Xload_inv[725]_no0 mux_1level_tapbuf_size2[69]->out mux_1level_tapbuf_size2[69]->out_out[35] gvdd_load 0 inv size=1
Xload_inv[726]_no0 mux_1level_tapbuf_size2[69]->out mux_1level_tapbuf_size2[69]->out_out[36] gvdd_load 0 inv size=1
Xload_inv[727]_no0 mux_1level_tapbuf_size2[69]->out mux_1level_tapbuf_size2[69]->out_out[37] gvdd_load 0 inv size=1
Xload_inv[728]_no0 mux_1level_tapbuf_size2[69]->out mux_1level_tapbuf_size2[69]->out_out[38] gvdd_load 0 inv size=1
Xload_inv[729]_no0 mux_1level_tapbuf_size2[69]->out mux_1level_tapbuf_size2[69]->out_out[39] gvdd_load 0 inv size=1
Xload_inv[730]_no0 mux_1level_tapbuf_size2[69]->out mux_1level_tapbuf_size2[69]->out_out[40] gvdd_load 0 inv size=1
Xload_inv[731]_no0 mux_1level_tapbuf_size2[69]->out mux_1level_tapbuf_size2[69]->out_out[41] gvdd_load 0 inv size=1
Xload_inv[732]_no0 mux_1level_tapbuf_size2[69]->out mux_1level_tapbuf_size2[69]->out_out[42] gvdd_load 0 inv size=1
Xload_inv[733]_no0 mux_1level_tapbuf_size2[69]->out mux_1level_tapbuf_size2[69]->out_out[43] gvdd_load 0 inv size=1
Xload_inv[734]_no0 mux_1level_tapbuf_size2[69]->out mux_1level_tapbuf_size2[69]->out_out[44] gvdd_load 0 inv size=1
Xload_inv[735]_no0 mux_1level_tapbuf_size2[69]->out mux_1level_tapbuf_size2[69]->out_out[45] gvdd_load 0 inv size=1
Xload_inv[736]_no0 mux_1level_tapbuf_size2[69]->out mux_1level_tapbuf_size2[69]->out_out[46] gvdd_load 0 inv size=1
Xload_inv[737]_no0 mux_1level_tapbuf_size2[69]->out mux_1level_tapbuf_size2[69]->out_out[47] gvdd_load 0 inv size=1
Xload_inv[738]_no0 mux_1level_tapbuf_size2[69]->out mux_1level_tapbuf_size2[69]->out_out[48] gvdd_load 0 inv size=1
Xload_inv[739]_no0 mux_1level_tapbuf_size2[69]->out mux_1level_tapbuf_size2[69]->out_out[49] gvdd_load 0 inv size=1
Xload_inv[740]_no0 mux_1level_tapbuf_size2[69]->out mux_1level_tapbuf_size2[69]->out_out[50] gvdd_load 0 inv size=1
Xload_inv[741]_no0 mux_1level_tapbuf_size2[69]->out mux_1level_tapbuf_size2[69]->out_out[51] gvdd_load 0 inv size=1
Xload_inv[742]_no0 mux_1level_tapbuf_size2[69]->out mux_1level_tapbuf_size2[69]->out_out[52] gvdd_load 0 inv size=1
Xload_inv[743]_no0 mux_1level_tapbuf_size2[69]->out mux_1level_tapbuf_size2[69]->out_out[53] gvdd_load 0 inv size=1
Xload_inv[744]_no0 mux_1level_tapbuf_size2[69]->out mux_1level_tapbuf_size2[69]->out_out[54] gvdd_load 0 inv size=1
Xload_inv[745]_no0 mux_1level_tapbuf_size2[69]->out mux_1level_tapbuf_size2[69]->out_out[55] gvdd_load 0 inv size=1
Xload_inv[746]_no0 mux_1level_tapbuf_size2[69]->out mux_1level_tapbuf_size2[69]->out_out[56] gvdd_load 0 inv size=1
Xload_inv[747]_no0 mux_1level_tapbuf_size2[69]->out mux_1level_tapbuf_size2[69]->out_out[57] gvdd_load 0 inv size=1
Xload_inv[748]_no0 mux_1level_tapbuf_size2[69]->out mux_1level_tapbuf_size2[69]->out_out[58] gvdd_load 0 inv size=1
Xload_inv[749]_no0 mux_1level_tapbuf_size2[69]->out mux_1level_tapbuf_size2[69]->out_out[59] gvdd_load 0 inv size=1
Xload_inv[750]_no0 mux_1level_tapbuf_size2[69]->out load_inv[750]_out gvdd_load 0 inv size=1
Xload_inv[751]_no0 mux_1level_tapbuf_size2[69]->out load_inv[751]_out gvdd_load 0 inv size=1
Xload_inv[752]_no0 mux_1level_tapbuf_size2[69]->out load_inv[752]_out gvdd_load 0 inv size=1
Xload_inv[753]_no0 mux_1level_tapbuf_size2[69]->out load_inv[753]_out gvdd_load 0 inv size=1
Xload_inv[754]_no0 mux_1level_tapbuf_size2[69]->out load_inv[754]_out gvdd_load 0 inv size=1
Xload_inv[755]_no0 mux_1level_tapbuf_size2[69]->out load_inv[755]_out gvdd_load 0 inv size=1
Xload_inv[756]_no0 mux_1level_tapbuf_size2[69]->out load_inv[756]_out gvdd_load 0 inv size=1
Xload_inv[757]_no0 mux_1level_tapbuf_size2[69]->out load_inv[757]_out gvdd_load 0 inv size=1
Xload_inv[758]_no0 mux_1level_tapbuf_size2[69]->out load_inv[758]_out gvdd_load 0 inv size=1
Xload_inv[759]_no0 mux_1level_tapbuf_size2[69]->out load_inv[759]_out gvdd_load 0 inv size=1
.meas tran sum_leakage_power_pb_mux[0to69]
+          param='sum_leakage_power_pb_mux[0to68]+leakage_grid[1][1]_clb[0]_mode[clb]_fle[9]_mode[n1_lut6]_ble6[0]_mode[ble6]_out[0]_mux1'
.meas tran sum_energy_per_cycle_pb_mux[0to69]
+          param='sum_energy_per_cycle_pb_mux[0to68]+energy_per_cycle_grid[1][1]_clb[0]_mode[clb]_fle[9]_mode[n1_lut6]_ble6[0]_mode[ble6]_out[0]_mux1'
***** Global VDD port *****
Vgvdd gvdd 0 vsp
***** Global GND port *****
Vggnd ggnd 0 0
***** Global Net for reset signal *****
Vgreset greset 0 0
Vgreset_inv greset_inv 0 vsp
***** Global Net for set signal *****
Vgset gset 0 0
Vgset_inv gset_inv 0 vsp
***** Global Net for configuration done signal *****
Vgconfig_done gconfig_done 0 0
Vgconfig_done_inv gconfig_done_inv 0 vsp
***** Global Clock signal *****
***** pulse(vlow vhigh tdelay trise tfall pulse_width period *****
Vgclock gclock 0 pulse(0 vsp 'clock_period'
+                      'clock_slew_pct_rise*clock_period' 'clock_slew_pct_fall*clock_period'
+                      '0.5*(1-clock_slew_pct_rise-clock_slew_pct_fall)*clock_period' 'clock_period')

***** pulse(vlow vhigh tdelay trise tfall pulse_width period *****
Vgclock_inv gclock_inv 0 pulse(0 vsp 'clock_period'
+                              'clock_slew_pct_rise*clock_period' 'clock_slew_pct_fall*clock_period'
+                              '0.5*(1-clock_slew_pct_rise-clock_slew_pct_fall)*clock_period' 'clock_period')
***** Connecting Global ports *****
Rzin[0] zin[0]  ggnd 0
Rshortwireclk[0] clk[0]  gclock 0
RshortwireReset[0] Reset[0]  greset 0
RshortwireSet[0] Set[0]  gset 0
***** End Connecting Global ports *****
***** Global Inputs for SRAMs *****
***** Global Inputs for SRAMs *****
Vsram->in sram->in 0 0
.nodeset V(sram->in) 0
***** Global VDD for SRAMs *****
Vgvdd_sram gvdd_sram 0 vsp
***** Global VDD for load inverters *****
Vgvdd_load gvdd_load 0 vsp
***** 6 Clock Simulation, accuracy=1e-13 *****
.tran 1e-13  '6*clock_period'
***** Generic Measurements for Circuit Parameters *****
.meas tran total_leakage_srams avg p(Vgvdd_sram) from=0 to='clock_period'
.meas tran total_dynamic_srams avg p(Vgvdd_sram) from='clock_period' to='6*clock_period'
.meas tran total_energy_per_cycle_srams param='total_dynamic_srams*clock_period'
.meas tran total_leakage_power_mux[0to69]
+          param='sum_leakage_power_mux[0to69]'
.meas tran total_energy_per_cycle_mux[0to69]
+          param='sum_energy_per_cycle_mux[0to69]'
.meas tran total_leakage_power_pb_mux
+          param='sum_leakage_power_pb_mux[0to69]'
.meas tran total_energy_per_cycle_pb_mux
+          param='sum_energy_per_cycle_pb_mux[0to69]'
.end
